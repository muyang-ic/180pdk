// *********************************************************************************************
//                                                                            
//                   *
//                               1.8 V STD-SVT  NMOS DEVICE MODELS            
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.43953+dvthn        k1=0.448                  k2=0.044342+dk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0034927135      lkvth0we=0
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00082854+dcitn
+ voff=-0.13055+dvoffn      nfactor=0.94972           eta0=0.22771+deta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030526+du0n          ua=-1.1118e-009           ub=2.3263e-018
+ uc=1.9167e-010            vsat=73329+dvsatn         a0=1.0724+da0n
+ ags=0.50072               a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.051375
+ dwg=0                     dwb=0                     pclm=0.71887+dpclmn
+ pdiblc1=0                 pdiblc2=0.000975+dpdiblc2n
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.24611586
+ kt1l=0                    kt2=-0.060191541          ute=-1.8116912
+ ua1=2.3415359e-009        ub1=-4.4298745e-018       uc1=-8.0699954e-011
+ prt=0                     at=67848.508              jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthn            wvth0=0+dwvthn
+ pvth0=0+dpvthn            lk2=0+dlk2                lcit=0+dlcitn
+ pcit=0+dpcitn             lvoff=0+dlvoffn           pvoff=0+dpvoffn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lu0=0+dlu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           pvsat=0+dpvsatn
+ la0=0+dla0n               pa0=0+dpa0n               lpclm=0+dlpclmn
+ ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n     ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.44000255+dvthn     lvth0=-4.6939282e-009+dlvthn
+ k1=0.448                  k2=0.044420158+dk2        lk2=-7.763527e-010+dlk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0035080237      lkvth0we=-1.5207765e-010
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00094159467+dcitn
+ lcit=-1.1229833e-009+dlcitn                         voff=-0.13088478+dvoffn
+ lvoff=3.3253987e-009+dlvoffn                        nfactor=0.94802421
+ lnfactor=1.6844423e-008   eta0=0.2200075+deta0n     leta0=7.650975e-008+dleta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.031147016+du0n       lu0=-6.1686146e-009+dlu0n ua=-1.0351999e-009
+ lua=-7.608768e-016        ub=2.2622927e-018         lub=6.3579065e-025
+ uc=1.9814412e-010         luc=-6.4308095e-017       vsat=73219.038+dvsatn
+ lvsat=0.0010922656+dlvsatn                          a0=1.0632966+da0n
+ la0=9.0425265e-008+dla0n  ags=0.47288051            lags=2.7653248e-007
+ a1=0                      a2=0.995                  b0=0
+ b1=0                      keta=-0.044517814         lketa=-6.8113118e-008
+ dwg=0                     dwb=0                     pclm=0.73030143+dpclmn
+ lpclm=-1.1354958e-007+dlpclmn                       pdiblc1=0
+ pdiblc2=0.00083459861+dpdiblc2n                     lpdiblc2=1.3946211e-009+dlpdiblc2n
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.24097779
+ lkt1=-5.1036979e-008      kt1l=0                    kt2=-0.061781821
+ lkt2=1.5796411e-008       ute=-1.8758               lute=6.3679863e-007
+ ua1=2.1882535e-009        lua1=1.5225695e-015       ub1=-4.4202733e-018
+ lub1=-9.5370005e-026      uc1=-9.4815908e-011       luc1=1.4021518e-016
+ prt=0                     at=67632.492              lat=0.0021457058
+ jss=2.85e-07              jsd=2.85e-07              jsws=6.9e-13
+ jswd=6.9e-13              jswgs=6.9e-13             jswgd=6.9e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn                   cjd=cjn                   mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.202
+ mjswd=0.202               pbswgs=0.952              pbswgd=0.952
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.541
+ mjswgd=0.541              tpb=1.49e-3               tcj=9.05e-4
+ tpbsw=8.94e-04            tcjsw=8.09e-04            tpbswg=0.00133
+ tcjswg=0.00088            xtis=3                    xtid=3
+ jtsswgs=1.09e-009         jtsswgd=1.09e-009         njtsswg=11.6
+ xtsswgs=0.2886            xtsswgd=0.2886            tnjtsswg=1.08
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-3.2e-008
+ lku0=2e-007               wku0=7e-007               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 wvth0=0+dwvthn
+ pvth0=0+dpvthn            pcit=0+dpcitn             pvoff=0+dpvoffn
+ peta0=0+dpeta0n           pu0=0+dpu0n               pvsat=0+dpvsatn
+ pa0=0+dpa0n               ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     3: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.42487782+dvthn     lvth0=1.2443907e-008+dlvthn
+ k1=0.448                  k2=0.045638784+dk2        lk2=-2.1571775e-009+dlk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0034998799      lkvth0we=-1.4284995e-010
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00046662469+dcitn
+ lcit=4.7267005e-010+dlcitn                          voff=-0.12040787+dvoffn
+ lvoff=-8.5459843e-009+dlvoffn                       nfactor=1.0247614
+ lnfactor=-7.0106516e-008  eta0=0.28753+deta0n       etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.021368288+du0n
+ lu0=4.9116625e-009+dlu0n  ua=-2.2464725e-009        lua=6.1161625e-016
+ ub=3.3377372e-018         lub=-5.8279547e-025       uc=1.5619583e-010
+ luc=-1.6776489e-017       vsat=81168.284+dvsatn     lvsat=-0.0079150256+dlvsatn
+ a0=1.6098828+da0n         la0=-5.289116e-007+dla0n  ags=0.84742922
+ lags=-1.4786866e-007      a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.11739531
+ lketa=1.4464376e-008      dwg=0                     dwb=0
+ pclm=0.61209779+dpclmn    lpclm=2.0386975e-008+dlpclmn
+ pdiblc1=0                 pdiblc2=0.0024032799+dpdiblc2n
+ lpdiblc2=-3.8285168e-010+dlpdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.28030251           lkt1=-6.4781365e-009
+ kt1l=0                    kt2=-0.050747054          lkt2=3.2929164e-009
+ ute=-1.3497898            lute=4.0776543e-008       ua1=3.8336541e-009
+ lua1=-3.4183397e-016      ub1=-5.1065691e-018       lub1=6.8227184e-025
+ uc1=3.805997e-013         luc1=3.2348021e-017       prt=0
+ at=96010.896              lat=-0.030009864          jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 wvth0=0+dwvthn            pvth0=0+dpvthn
+ pcit=0+dpcitn             pvoff=0+dpvoffn           leta0=0+dleta0n
+ peta0=0+dpeta0n           pu0=0+dpu0n               pvsat=0+dpvsatn
+ pa0=0+dpa0n               ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     4: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.46146692+dvthn     lvth0=-3.4028302e-009+dlvthn
+ k1=0.448                  k2=0.039663073+dk2        lk2=4.3090269e-010+dlk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.00349988        lkvth0we=-1.4284997e-010
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00061599596+dcitn
+ lcit=3.7870453e-012+dlcitn                          voff=-0.14584802+dvoffn
+ lvoff=2.4721416e-009+dlvoffn                        nfactor=0.78346906
+ lnfactor=3.4397209e-008   eta0=0.28753+deta0n       etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.030914951+du0n
+ lu0=7.7700251e-010+dlu0n  ua=-7.1464787e-010        lua=-5.1817006e-017
+ ub=1.5421034e-018         lub=1.9489354e-025        uc=7.8458172e-011
+ luc=1.6891692e-017        vsat=61073.15+dvsatn      lvsat=0.0007881769+dlvsatn
+ a0=0.20832912+da0n        la0=7.8101305e-008+dla0n  ags=0.31869166
+ lags=8.1127573e-008       a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.09467464
+ lketa=4.6240528e-009      dwg=0                     dwb=0
+ pclm=0.64898747+dpclmn    lpclm=4.4100556e-009+dlpclmn
+ pdiblc1=0                 pdiblc2=0.001415142+dpdiblc2n
+ lpdiblc2=4.5110843e-011+dlpdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.27298647           lkt1=-9.6467128e-009
+ kt1l=0                    kt2=-0.039573915          lkt2=-1.5461699e-009
+ ute=-1.2573881            lute=7.5736315e-010       ua1=2.9375154e-009
+ lua1=4.6283725e-017       ub1=-3.2787121e-018       lub1=-1.0937304e-025
+ uc1=7.8991529e-011        luc1=-1.6983721e-018      prt=0
+ at=27462.292              lat=-0.00032146321        jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 wvth0=0+dwvthn            pvth0=0+dpvthn
+ pcit=0+dpcitn             pvoff=0+dpvoffn           leta0=0+dleta0n
+ peta0=0+dpeta0n           pu0=0+dpu0n               pvsat=0+dpvsatn
+ pa0=0+dpa0n               ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     5: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.43767024+dvthn     wvth0=1.8615454e-008+dwvthn
+ k1=0.448                  k2=0.044105166+dk2        wk2=2.3706154e-009
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0034939762      lkvth0we=0
+ wkvth0we=-1.2638696e-011  pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00079963881+dcitn
+ wcit=2.8928938e-010       voff=-0.12992046+dvoffn   wvoff=-6.3014618e-009
+ nfactor=0.88693351        wnfactor=6.2846762e-007   eta0=0.21639887+deta0n
+ weta0=1.1321993e-007      etab=-0.308               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.02998869+du0n        wu0=5.3782564e-009
+ ua=-1.203133e-009         wua=9.1420727e-016        ub=2.4226144e-018
+ wub=-9.6406862e-025       uc=2.0880233e-010         wuc=-1.7148782e-016
+ vsat=73808.304+dvsatn     wvsat=-0.0047976413       a0=1.0648537+da0n
+ wa0=7.5534989e-008        ags=0.50587729            wags=-5.1622455e-008
+ a1=0                      a2=0.995                  b0=0
+ b1=0                      keta=-0.053402592         wketa=2.0295385e-008
+ dwg=0                     dwb=0                     pclm=0.72643962+dpclmn
+ wpclm=-7.5768887e-008     pdiblc1=0                 pdiblc2=0.00097154989+dpdiblc2n
+ wpdiblc2=3.4534212e-011   pdiblcb=0                 drout=0.5
+ pvag=0.6279               delta=0.005               pscbe1=4.5e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=90.88                 rdw=90.88
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.454e-007         alpha1=2.295              beta0=17.8
+ agidl=2.593e-009          bgidl=1.8508e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5.346                noff=1.973                voffcv=-0.0904
+ kt1=-0.24433236           wkt1=-1.7852096e-008      kt1l=0
+ kt2=-0.061344831          wkt2=1.1543968e-008       ute=-1.8450159
+ wute=3.3356664e-007       ua1=2.2889782e-009        wua1=5.2608194e-016
+ ub1=-4.4511878e-018       wub1=2.1333736e-025       uc1=-8.7610598e-011
+ wuc1=6.9172781e-017       prt=0                     at=64287.823
+ wat=0.035641033           jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1.00e-05            sbref=1.00e-05            wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthn            pvth0=0+dpvthn            lk2=0+dlk2
+ lcit=0+dlcitn             pcit=0+dpcitn             lvoff=0+dlvoffn
+ pvoff=0+dpvoffn           leta0=0+dleta0n           peta0=0+dpeta0n
+ lu0=0+dlu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ pvsat=0+dpvsatn           la0=0+dla0n               pa0=0+dpa0n
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n
+ ppdiblc2=0+dppdiblc2n     fnoimod=1                 noia=noian
+ noib=noibn                noic=noicn                em=3.00e7
+ ef=0.904                  minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.43826899+dvthn     lvth0=-5.9474128e-009+dlvthn
+ wvth0=1.7352315e-008+dwvthn                         pvth0=1.254688e-014+dpvthn
+ k1=0.448                  k2=0.044096635+dk2        lk2=8.473674e-011+dlk2
+ wk2=3.2383366e-009        pk2=-8.6191608e-015       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035094668      lkvth0we=-1.5387034e-010  wkvth0we=-1.4445197e-011
+ pkvth0we=1.794415e-017    k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00091692734+dcitn   lcit=-1.1650387e-009+dlcitn
+ wcit=2.4691011e-010       pcit=4.2095749e-016+dpcitn
+ voff=-0.13043683+dvoffn   lvoff=5.1291508e-009+dlvoffn
+ wvoff=-4.4838181e-009     pvoff=-1.8054837e-014+dpvoffn
+ nfactor=0.88311971        lnfactor=3.7882923e-008   wnfactor=6.4966815e-007
+ pnfactor=-2.1058697e-013  eta0=0.20763762+deta0n    leta0=8.7026363e-008+dleta0n
+ weta0=1.2381754e-007      peta0=-1.0526709e-013+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030734961+du0n       lu0=-7.4127816e-009+dlu0n wu0=4.1245074e-009
+ pu0=1.2453614e-014+dpu0n  ua=-1.1100275e-009        lua=-9.2482661e-016
+ wua=7.489948e-016         pua=1.641072e-021         ub=2.3448197e-018
+ lub=7.727422e-025         wub=-8.2606234e-025       pub=-1.3708302e-030
+ uc=2.1675785e-010         luc=-7.9022914e-017       wuc=-1.8631596e-016
+ puc=1.4728946e-022        vsat=73706.519+dvsatn     lvsat=0.001011044+dlvsatn
+ wvsat=-0.0048794884       pvsat=8.1299557e-010+dpvsatn
+ a0=1.0494623+da0n         la0=1.5288501e-007+dla0n  wa0=1.3847577e-007
+ pa0=-6.2519711e-013+dpa0n ags=0.48226057            lags=2.3458734e-007
+ wags=-9.3890644e-008      pags=4.1985414e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.046062599         lketa=-7.2908884e-008     wketa=1.5462685e-008
+ pketa=4.8003693e-014      dwg=0                     dwb=0
+ pclm=0.73944236+dpclmn    lpclm=-1.2915748e-007+dlpclmn
+ wpclm=-9.1496997e-008     ppclm=1.5622889e-013+dppclmn
+ pdiblc1=0                 pdiblc2=0.00082255572+dpdiblc2n
+ lpdiblc2=1.479974e-009+dlpdiblc2n                   wpdiblc2=1.2054455e-010
+ ppdiblc2=-8.5434924e-016+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.23907403           lkt1=-5.2231546e-008
+ wkt1=-1.9055864e-008      pkt1=1.1957141e-014       kt1l=0
+ kt2=-0.063097929          lkt2=1.7413704e-008       wkt2=1.3173717e-008
+ pkt2=-1.6188456e-014      ute=-1.9123217            lute=6.6855562e-007
+ wute=3.6556821e-007       pute=-3.1787476e-013      ua1=2.1228227e-009
+ lua1=1.6504387e-015       wua1=6.5493592e-016       pua1=-1.2799195e-021
+ ub1=-4.4301109e-018       lub1=-2.0935864e-025      wub1=9.8470839e-026
+ pub1=1.1409807e-030       uc1=-1.0240556e-010       luc1=1.4695986e-016
+ wuc1=7.5969403e-017       puc1=-6.7511529e-023      prt=0
+ at=63802.066              lat=0.0048250702          wat=0.038341033
+ pat=-2.6819365e-008       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     7: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.42037368+dvthn     lvth0=1.4329762e-008+dlvthn
+ wvth0=4.5084673e-008+dwvthn                         pvth0=-1.8876655e-014+dpvthn
+ k1=0.448                  k2=0.046221224+dk2        lk2=-2.3226355e-009+dlk2
+ wk2=-5.8299975e-009       pk2=1.6561685e-015        k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035012271      lkvth0we=-1.4453387e-010  wkvth0we=-1.3484334e-011
+ pkvth0we=1.6855396e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00058574619+dcitn  lcit=5.3764069e-010+dlcitn
+ wcit=1.1923586e-009       pcit=-6.5033018e-016+dpcitn
+ voff=-0.11697501+dvoffn   lvoff=-1.0124436e-008+dlvoffn
+ wvoff=-3.4361596e-008     pvoff=1.5799673e-014+dpvoffn
+ nfactor=0.97842413        lnfactor=-7.0106516e-008  wnfactor=4.6381786e-007
+ pnfactor=-3.6153196e-028  eta0=0.2857596+deta0n     leta0=-1.4936512e-009+dleta0n
+ weta0=1.7721043e-008      peta0=1.4950851e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.018994069+du0n       lu0=5.8908231e-009+dlu0n  wu0=2.3764981e-008
+ pu0=-9.8010062e-015+dpu0n ua=-2.5857121e-009        lua=7.4727158e-016
+ wua=3.3956523e-015        pua=-1.3578556e-021       ub=3.6579891e-018
+ lub=-7.1521005e-025       wub=-3.2055939e-024       pub=1.325417e-030
+ uc=1.6778828e-010         luc=-2.3535502e-017       wuc=-1.1603581e-016
+ puc=6.7655012e-023        vsat=82472.125+dvsatn     lvsat=-0.0089212647+dlvsatn
+ wvsat=-0.013050925        pvsat=1.0072051e-008+dpvsatn
+ a0=1.7153328+da0n         la0=-6.016129e-007+dla0n  wa0=-1.0555125e-006
+ pa0=7.2771096e-013+dpa0n  ags=0.8525523             lags=-1.8499023e-007
+ wags=-5.1280026e-008      pags=3.7157205e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.12659406          lketa=1.8341317e-008      wketa=9.2075794e-008
+ pketa=-3.8806621e-014     dwg=0                     dwb=0
+ pclm=0.60499108+dpclmn    lpclm=2.3189257e-008+dlpclmn
+ wpclm=7.1135264e-008      ppclm=-2.8049725e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0025232125+dpdiblc2n
+ lpdiblc2=-4.4704014e-010+dlpdiblc2n                 wpdiblc2=-1.2004774e-009
+ ppdiblc2=6.4250076e-016+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.28058066           lkt1=-5.2003825e-009
+ wkt1=2.7841751e-009       pkt1=-1.2789807e-014      kt1l=0
+ kt2=-0.051128002          lkt2=3.8505801e-009       wkt2=3.8131443e-009
+ pkt2=-5.5819908e-015      ute=-1.3645922            lute=4.7923298e-008
+ wute=1.4816586e-007       pute=-7.1536156e-014      ua1=3.9108885e-009
+ lua1=-3.7561866e-016      wua1=-7.7308516e-016      pua1=3.3817117e-022
+ ub1=-5.2851432e-018       lub1=7.594785e-025        wub1=1.7874554e-024
+ pub1=-7.7280775e-031      uc1=-4.4561452e-012       luc1=3.5973378e-017
+ wuc1=4.8413882e-017       puc1=-3.6288368e-023      prt=0
+ at=93916.287              lat=-0.029297354          wat=0.020966199
+ pat=-7.1319407e-009       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     8: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.46153716+dvthn     lvth0=-3.4981445e-009+dlvthn
+ wvth0=-7.0316591e-010+dwvthn                        pvth0=9.5405814e-016+dpvthn
+ k1=0.448                  k2=0.04005708+dk2         lk2=3.4705556e-010+dlk2
+ wk2=-3.9438461e-009       pk2=8.3927631e-016        k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035012271      lkvth0we=-1.4453389e-010  wkvth0we=-1.3484357e-011
+ pkvth0we=1.6855406e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00063596926+dcitn   lcit=8.5157293e-012+dlcitn
+ wcit=-1.9992482e-010      pcit=-4.7332235e-017+dpcitn
+ voff=-0.14662081+dvoffn   lvoff=2.7151615e-009+dlvoffn
+ wvoff=7.7353926e-009      pvoff=-2.4325323e-015+dpvoffn
+ nfactor=0.72621499        lnfactor=3.9125262e-008   wnfactor=5.7309035e-007
+ pnfactor=-4.7325917e-014  eta0=0.28035301+deta0n    leta0=8.4793969e-010+dleta0n
+ weta0=7.1838771e-008      peta0=-8.4875371e-015+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030600569+du0n       lu0=8.6404784e-010+dlu0n  wu0=3.1468385e-009
+ pu0=-8.7128886e-016+dpu0n ua=-7.360552e-010         lua=-5.3814819e-017
+ wua=2.1427874e-016        pua=1.9997311e-023        ub=1.5214649e-018
+ lub=2.1011858e-025        wub=2.0658252e-025        pub=-1.5239657e-031
+ uc=7.1563125e-011         luc=1.8139615e-017        wuc=6.9016661e-017
+ puc=-1.2491212e-023       vsat=59837.656+dvsatn     lvsat=0.00088172379+dlvsatn
+ wvsat=0.012366802         pvsat=-9.36367e-010+dpvsatn
+ a0=0.12876526+da0n        la0=8.5529509e-008+dla0n  wa0=7.9640237e-007
+ pa0=-7.4353352e-014+dpa0n ags=0.19374941            lags=1.003373e-007
+ wags=1.2506219e-006       pags=-1.9228168e-013      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.094572384         lketa=4.4727282e-009      wketa=-1.0235369e-009
+ pketa=1.5146989e-015      dwg=0                     dwb=0
+ pclm=0.64375475+dpclmn    lpclm=6.400715e-009+dlpclmn
+ wpclm=5.2377423e-008      ppclm=-1.9925704e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0013400495+dpdiblc2n
+ lpdiblc2=6.5387753e-011+dlpdiblc2n                  wpdiblc2=7.5164568e-010
+ ppdiblc2=-2.0296376e-016+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.26854017           lkt1=-1.0415119e-008
+ wkt1=-4.4505704e-008      pkt1=7.6914398e-015       kt1l=0
+ kt2=-0.038022537          lkt2=-1.825397e-009       wkt2=-1.5528675e-008
+ pkt2=2.7949512e-015       ute=-1.2578727            lute=1.7030936e-009
+ wute=4.8507534e-009       pute=-9.4663839e-015      ua1=2.9101028e-009
+ lua1=5.7821643e-017       wua1=2.7438913e-016       pua1=-1.1548994e-022
+ ub1=-3.2377504e-018       lub1=-1.2724735e-025      wub1=-4.1001048e-025
+ pub1=1.7891473e-031       uc1=8.2624854e-011        luc1=-1.7414029e-018
+ wuc1=-3.6368127e-017      puc1=4.3072039e-025       prt=0
+ at=26853.963              lat=-0.00025266125        wat=0.0060891249
+ pat=-6.8868002e-010       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     9: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45091968+dvthn     wvth0=2.5889311e-009+dwvthn
+ k1=0.448                  k2=0.049658408+dk2        wk2=-4.3465863e-009
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.003492826       lkvth0we=0
+ wkvth0we=-1.1247497e-011  pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0011644892+dcitn
+ wcit=-1.5203366e-010      voff=-0.12502536+dvoffn   wvoff=-1.2222573e-008
+ nfactor=1.3196496         wnfactor=1.0505424e-007   eta0=0.38866768+deta0n
+ weta0=-9.5156426e-008     etab=-0.308               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.037683336+du0n       wu0=-3.9291872e-009
+ ua=-2.803732e-010         wua=-2.0196304e-016       ub=1.6975264e-018
+ wub=-8.7002173e-026       uc=5.6835816e-011         wuc=1.2330885e-017
+ vsat=56060.96+dvsatn      wvsat=0.016669546         a0=1.2341704+da0n
+ wa0=-1.2927044e-007       ags=0.49009232            wags=-3.252895e-008
+ a1=0                      a2=0.995                  b0=0
+ b1=0                      keta=-0.02910376          wketa=-9.0964823e-009
+ dwg=0                     dwb=0                     pclm=0.6638+dpclmn
+ pdiblc1=0                 pdiblc2=0.001072536+dpdiblc2n
+ wpdiblc2=-8.7618586e-011  pdiblcb=0                 drout=0.5
+ pvag=0.6279               delta=0.005               pscbe1=4.5e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=90.88                 rdw=90.88
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.454e-007         alpha1=2.295              beta0=17.8
+ agidl=2.593e-009          bgidl=1.8508e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5.346                noff=1.973                voffcv=-0.0904
+ kt1=-0.26270789           wkt1=4.3749413e-009       kt1l=0
+ kt2=-0.055266569          wkt2=4.1917031e-009       ute=-1.6297245
+ wute=7.3150159e-008       ua1=2.9265549e-009        wua1=-2.4513091e-016
+ ub1=-4.6663733e-018       wub1=4.7362574e-025       uc1=-1.5828853e-011
+ wuc1=-1.7654419e-017      prt=0                     at=97530.221
+ wat=-0.0045689711         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1.00e-05            sbref=1.00e-05            wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthn            pvth0=0+dpvthn            lk2=0+dlk2
+ lcit=0+dlcitn             pcit=0+dpcitn             lvoff=0+dlvoffn
+ pvoff=0+dpvoffn           leta0=0+dleta0n           peta0=0+dpeta0n
+ lu0=0+dlu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ pvsat=0+dpvsatn           la0=0+dla0n               pa0=0+dpa0n
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n
+ ppdiblc2=0+dppdiblc2n     fnoimod=1                 noia=noian
+ noib=noibn                noic=noicn                em=3.00e7
+ ef=0.904                  minr=1e-3
 
 
     10: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45009359+dvthn     lvth0=8.2056515e-009+dlvthn
+ wvth0=3.0492775e-009+dwvthn                         pvth0=-4.5726669e-015+dpvthn
+ k1=0.448                  k2=0.0506837+dk2          lk2=-1.0184325e-008+dlk2
+ wk2=-4.7293768e-009       pk2=3.8022964e-015        k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035081523      lkvth0we=-1.5223742e-010  wkvth0we=-1.2855149e-011
+ pkvth0we=1.5968969e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0012816735+dcitn    lcit=-1.1640036e-009+dlcitn
+ wcit=-1.9428688e-010      pcit=4.197055e-016+dpcitn voff=-0.12390125+dvoffn
+ lvoff=-1.116587e-008+dlvoffn                        wvoff=-1.238925e-008
+ pvoff=1.6556208e-015+dpvoffn                        nfactor=1.3034321
+ lnfactor=1.610905e-007    wnfactor=1.4125833e-007   pnfactor=-3.5961885e-013
+ eta0=0.38567368+deta0n    leta0=2.9739706e-008+dleta0n
+ weta0=-9.1534883e-008     peta0=-3.5973148e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.037135421+du0n       lu0=5.4424908e-009+dlu0n  wu0=-3.6174896e-009
+ pu0=-3.0961235e-015+dpu0n ua=-3.4387548e-010        lua=6.3077452e-016
+ wua=-1.777427e-016        pua=-2.405831e-022        ub=1.7416045e-018
+ lub=-4.3783223e-025       wub=-9.6413196e-026       pub=9.3480629e-032
+ uc=5.2319544e-011         luc=4.486058e-017         wuc=1.2588611e-017
+ puc=-2.5600177e-024       vsat=54415.882+dvsatn     lvsat=0.016340723+dlvsatn
+ wvsat=0.018454465         pvsat=-1.7729784e-008+dpvsatn
+ a0=1.2658264+da0n         la0=-3.1444254e-007+dla0n wa0=-1.2323831e-007
+ pa0=-5.9917704e-014+dpa0n ags=0.42466814            lags=6.4986497e-007
+ wags=-2.4226841e-008      pags=-8.2465682e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.02494072          lketa=-4.1351896e-008     wketa=-1.008634e-008
+ pketa=9.8323601e-015      dwg=0                     dwb=0
+ pclm=0.6638+dpclmn        pdiblc1=0                 pdiblc2=0.0010118305+dpdiblc2n
+ lpdiblc2=6.0299404e-010+dlpdiblc2n                  wpdiblc2=-1.0840221e-010
+ ppdiblc2=2.0644577e-016+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.25901356           lkt1=-3.6696172e-008
+ wkt1=5.0629891e-009       pkt1=-6.8344476e-015      kt1l=0
+ kt2=-0.056213203          lkt2=9.4030112e-009       wkt2=4.8459522e-009
+ pkt2=-6.4987215e-015      ute=-1.676861             lute=4.6821162e-007
+ wute=8.0754901e-008       pute=-7.5538655e-014      ua1=2.8875828e-009
+ lua1=3.871136e-016        wua1=-2.7011793e-016      pua1=2.481985e-022
+ ub1=-4.7956442e-018       lub1=1.2840609e-024       wub1=5.4061989e-025
+ pub1=-6.6545954e-031      uc1=-2.6953883e-011       luc1=1.1050604e-016
+ wuc1=-1.5296949e-017      puc1=-2.3416982e-023      prt=0
+ at=100664.73              lat=-0.031135429          wat=-0.0062480496
+ pat=1.6678455e-008        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     11: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.46386651+dvthn     lvth0=-7.4004438e-009+dlvthn
+ wvth0=-7.5242539e-009+dwvthn                        pvth0=7.4082015e-015+dpvthn
+ k1=0.448                  k2=0.041798436+dk2        lk2=-1.164329e-010+dlk2
+ wk2=-4.8019262e-010       pk2=-1.0124542e-015       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0034999999      lkvth0we=-1.4299998e-010  wkvth0we=-1.2000002e-011
+ pkvth0we=1.5000003e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0002093576+dcitn    lcit=5.1037543e-011+dlcitn
+ wcit=2.3060105e-010       pcit=-6.1735013e-017+dpcitn
+ voff=-0.14158636+dvoffn   lvoff=8.8731293e-009+dlvoffn
+ wvoff=-4.5917007e-009     pvoff=-7.179782e-015+dpvoffn
+ nfactor=1.5074714         lnfactor=-7.0106516e-008  wnfactor=-1.7611776e-007
+ pnfactor=-8.4625901e-029  eta0=0.444895+deta0n      leta0=-3.7363969e-008+dleta0n
+ weta0=-1.7476914e-007     peta0=5.8339587e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.047238653+du0n       lu0=-6.0054812e-009+dlu0n wu0=-1.0399669e-008
+ pu0=4.5887635e-015+dpu0n  ua=7.1915788e-010         lua=-5.7374858e-016
+ wua=-6.0191843e-016       pua=2.4005042e-022        ub=1.1708869e-018
+ lub=2.0884787e-025        wub=-1.9719508e-025       pub=2.0767658e-031
+ uc=6.3459404e-011         luc=3.2238005e-017        wuc=1.0160408e-017
+ puc=1.9137854e-025        vsat=72259.383+dvsatn     lvsat=-0.0038777484+dlvsatn
+ wvsat=-0.00069759276      pvsat=3.9714134e-009+dpvsatn
+ a0=1.1074481+da0n         la0=-1.3498409e-007+dla0n wa0=-3.2021516e-007
+ pa0=1.6327676e-013+dpa0n  ags=1.0257791             lags=-3.1253821e-008
+ wags=-2.6081511e-007      pags=1.8561249e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.044894245         lketa=-1.8742556e-008     wketa=-6.7483042e-009
+ pketa=6.0500312e-015      dwg=0                     dwb=0
+ pclm=0.74766895+dpclmn    lpclm=-9.5031906e-008+dlpclmn
+ wpclm=-1.0144788e-007     ppclm=1.1495059e-013+dppclmn
+ pdiblc1=0                 pdiblc2=0.0014356508+dpdiblc2n
+ lpdiblc2=1.2276324e-010+dlpdiblc2n                  wpdiblc2=1.1503719e-010
+ ppdiblc2=-4.6733404e-017+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.26914528           lkt1=-2.5215912e-008
+ wkt1=-1.1048056e-008      pkt1=1.1420977e-014       kt1l=0
+ kt2=-0.046010664          lkt2=-2.157486e-009       wkt2=-2.3767884e-009
+ pkt2=1.6853658e-015       ute=-1.2217685            lute=-4.7453698e-008
+ wute=-2.4593713e-008      pute=4.3831859e-014       ua1=3.2126425e-009
+ lua1=1.8788546e-017       wua1=7.1513245e-017       pua1=-1.3890378e-022
+ ub1=-3.4530876e-018       lub1=-2.3718997e-025      wub1=-4.2859905e-025
+ pub1=4.3276244e-031       uc1=9.385696e-011         luc1=-2.6384728e-017
+ wuc1=-7.050565e-017       puc1=3.9139997e-023       prt=0
+ at=101453.47              lat=-0.032029141          wat=0.011849228
+ pat=-3.8275708e-009       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
     12: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45100766+dvthn     lvth0=-1.8312768e-009+dlvthn
+ wvth0=1.2033323e-008+dwvthn                         pvth0=-1.0621851e-015+dpvthn
+ k1=0.448                  k2=0.038163914+dk2        lk2=1.4576788e-009+dlk2
+ wk2=-1.6538724e-009       pk2=-5.0413351e-016       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035            lkvth0we=-1.4299999e-010  wkvth0we=-1.1999982e-011
+ pkvth0we=1.4999994e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.000449348+dcitn     lcit=-5.2902299e-011+dlcitn
+ wcit=2.5812259e-011       pcit=2.6959011e-017+dpcitn
+ voff=-0.12170577+dvoffn   lvoff=2.6284605e-010+dlvoffn
+ wvoff=-2.2401838e-008     pvoff=5.3378843e-016+dpvoffn
+ nfactor=1.3456            wnfactor=-1.7611776e-007  eta0=0.34772908+deta0n
+ leta0=4.7185912e-009+dleta0n                        weta0=-9.6593161e-009
+ peta0=-1.3169477e-014+dpeta0n                       etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.03277883+du0n
+ lu0=2.5706843e-010+dlu0n  wu0=5.1201478e-010        pu0=-1.3708657e-016+dpu0n
+ ua=-4.8910711e-010        lua=-5.0449016e-017       wua=-8.4429657e-017
+ pua=1.5926036e-023        ub=1.3163084e-018         lub=1.4586584e-025
+ wub=4.5473991e-025        pub=-7.4676462e-032       uc=1.0368654e-010
+ luc=1.4815632e-017        wuc=3.0160177e-017        puc=-8.4705214e-024
+ vsat=61090.882+dvsatn     lvsat=0.00095932931+dlvsatn
+ wvsat=0.010850899         pvsat=-1.0302386e-009+dpvsatn
+ a0=0.75505102+da0n        la0=1.7639096e-008+dla0n  wa0=3.8847114e-008
+ pa0=7.7668912e-015+dpa0n  ags=1.0232614             lags=-3.0163421e-008
+ wags=2.4724421e-007       pags=-3.4428006e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.10179985          lketa=5.9032598e-009      wketa=7.7188011e-009
+ pketa=-2.1567209e-016     dwg=0                     dwb=0
+ pclm=0.56941084+dpclmn    lpclm=-1.782832e-008+dlpclmn
+ wpclm=1.4230381e-007      ppclm=9.381736e-015+dppclmn
+ pdiblc1=0                 pdiblc2=0.0020754301+dpdiblc2n
+ lpdiblc2=-1.5432519e-010+dlpdiblc2n                 wpdiblc2=-1.3787073e-010
+ ppdiblc2=6.2801017e-017+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.31710055           lkt1=-4.4464872e-009
+ wkt1=1.4232929e-008       pkt1=4.717827e-016        kt1l=0
+ kt2=-0.052717218          lkt2=7.4712251e-010       wkt2=2.2460105e-009
+ pkt2=-3.1676838e-016      ute=-1.3166839            lute=-6.3458267e-009
+ wute=7.5988759e-008       pute=2.6959011e-016       ua1=3.2603755e-009
+ lua1=-1.8846444e-018      wua1=-1.493008e-016       pua1=-4.3269213e-023
+ ub1=-3.9051406e-018       lub1=-4.1405846e-026      wub1=3.972647e-025
+ pub1=7.5080847e-032       uc1=4.9651032e-011        luc1=-7.239141e-018
+ wuc1=3.5170072e-018       puc1=7.0807845e-024       prt=0
+ at=28649.452              lat=-0.00049772277        wat=0.003917302
+ pat=-3.9225362e-010       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     13: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45303175+dvthn     wvth0=1.5126177e-009+dwvthn
+ k1=0.448                  k2=0.049498679+dk2        wk2=-4.2651883e-009
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.003492826       lkvth0we=0
+ wkvth0we=-1.1247478e-011  pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00089942525+dcitn
+ wcit=-1.6957068e-011      voff=-0.14737457+dvoffn   wvoff=-8.3341628e-010
+ nfactor=1.658695          wnfactor=-6.7723276e-008  eta0=0.17743427+deta0n
+ weta0=1.248812e-008       etab=-0.308               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.025695765+du0n       wu0=2.1796789e-009
+ ua=-7.1525143e-010        wua=1.9650906e-017        ub=9.9908335e-019
+ wub=2.689244e-025         uc=6.9611373e-011         wuc=5.8204612e-018
+ vsat=101331.99+dvsatn     wvsat=-0.0064005714       a0=0.96639923+da0n
+ wa0=7.1857545e-009        ags=0.29637191            wags=6.6190971e-008
+ a1=0                      a2=0.995                  b0=0
+ b1=0                      keta=-0.061694138         wketa=7.5115744e-009
+ dwg=0                     dwb=0                     pclm=0.69121603+dpclmn
+ wpclm=-1.3971207e-008     pdiblc1=0                 pdiblc2=0.00058465252+dpdiblc2n
+ wpdiblc2=1.6100684e-010   pdiblcb=0                 drout=0.5
+ pvag=0.6279               delta=0.005               pscbe1=4.5e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=90.88                 rdw=90.88
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.454e-007         alpha1=2.295              beta0=17.8
+ agidl=2.593e-009          bgidl=1.8508e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5.346                noff=1.973                voffcv=-0.0904
+ kt1=-0.26006509           wkt1=3.0281688e-009       kt1l=0
+ kt2=-0.054118684          wkt2=3.6067408e-009       ute=-1.4386321
+ wute=-2.4230528e-008      ua1=2.9965633e-009        wua1=-2.8080718e-016
+ ub1=-4.2139758e-018       wub1=2.4308397e-025       uc1=-3.0422229e-011
+ wuc1=-1.0217634e-017      prt=0                     at=55390.665
+ wat=0.016905347           jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1.00e-05            sbref=1.00e-05            wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthn            pvth0=0+dpvthn            lk2=0+dlk2
+ lcit=0+dlcitn             pcit=0+dpcitn             lvoff=0+dlvoffn
+ pvoff=0+dpvoffn           leta0=0+dleta0n           peta0=0+dpeta0n
+ lu0=0+dlu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ pvsat=0+dpvsatn           la0=0+dla0n               pa0=0+dpa0n
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n
+ ppdiblc2=0+dppdiblc2n     fnoimod=1                 noia=noian
+ noib=noibn                noic=noicn                em=3.00e7
+ ef=0.904                  minr=1e-3
 
 
     14: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45234877+dvthn     lvth0=6.7841929e-009+dlvthn
+ wvth0=1.9000387e-009+dwvthn                         pvth0=-3.8482916e-015+dpvthn
+ k1=0.448                  k2=0.049708891+dk2        lk2=-2.0880632e-009+dlk2
+ wk2=-4.2326145e-009       pk2=-3.2355865e-016       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035081523      lkvth0we=-1.5223736e-010  wkvth0we=-1.2855127e-011
+ pkvth0we=1.5968941e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00093598992+dcitn   lcit=-3.6320049e-010+dlcitn
+ wcit=-1.8126514e-011      pcit=1.1616217e-017+dpcitn
+ voff=-0.14627576+dvoffn   lvoff=-1.0914586e-008+dlvoffn
+ wvoff=-9.8720172e-010     pvoff=1.5275661e-015+dpvoffn
+ nfactor=1.7223427         lnfactor=-6.3221952e-007  wnfactor=-7.2218542e-008
+ pnfactor=4.4651933e-014   eta0=0.18419492+deta0n    leta0=-6.7154174e-008+dleta0n
+ weta0=1.1138695e-008      peta0=1.3403973e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.025734547+du0n       lu0=-3.8522805e-010+dlu0n wu0=2.1923957e-009
+ pu0=-1.2631797e-016+dpu0n ua=-7.4834311e-010        lua=3.2870292e-016
+ wua=2.8374005e-017        pua=-8.6647412e-023       ub=1.0002368e-018
+ lub=-1.145736e-026        wub=2.8138778e-025        pub=-1.238e-031
+ uc=6.3534915e-011         luc=6.0358059e-017        wuc=6.8732577e-018
+ puc=-1.0457533e-023       vsat=104447.26+dvsatn     lvsat=-0.030944327+dlvsatn
+ wvsat=-0.0070415271       pvsat=6.3666774e-009+dpvsatn
+ a0=1.0509621+da0n         la0=-8.3997116e-007+dla0n wa0=-1.374343e-008
+ pa0=2.0789168e-013+dpa0n  ags=0.23996998            lags=5.6024604e-007
+ wags=6.9895341e-008       pags=-3.6795879e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.061786008         lketa=9.1255707e-010      wketa=8.6900186e-009
+ pketa=-1.1705605e-014     dwg=0                     dwb=0
+ pclm=0.69474615+dpclmn    lpclm=-3.5065083e-008+dlpclmn
+ wpclm=-1.5770158e-008     ppclm=1.7869166e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0004881786+dpdiblc2n
+ lpdiblc2=9.5828501e-010+dlpdiblc2n                  wpdiblc2=1.5845079e-010
+ ppdiblc2=2.5389492e-017+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.25492349           lkt1=-5.1071948e-008
+ wkt1=2.978693e-009        pkt1=4.9144824e-016       kt1l=0
+ kt2=-0.054481381          lkt2=3.6027024e-009       wkt2=3.9634154e-009
+ pkt2=-3.5428841e-015      ute=-1.4614899            lute=2.270494e-007
+ wute=-2.8998185e-008      pute=4.7357614e-014       ua1=2.9533953e-009
+ lua1=4.2879233e-016       wua1=-3.0365594e-016      pua1=2.2695902e-022
+ ub1=-4.2552952e-018       lub1=4.1043047e-025       wub1=2.6525806e-025
+ pub1=-2.2025749e-031      uc1=-3.4311091e-011       luc1=3.8628462e-017
+ wuc1=-1.1547715e-017      puc1=1.321183e-023        prt=0
+ at=49816.344              lat=0.055370285           wat=0.01966429
+ pat=-2.7404857e-008       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     15: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.44828089+dvthn     lvth0=1.1393503e-008+dlvthn
+ wvth0=4.181767e-010+dwvthn                          pvth0=-2.1691937e-015+dpvthn
+ k1=0.448                  k2=0.048140709+dk2        lk2=-3.1115533e-010+dlk2
+ wk2=-3.7122147e-009       pk2=-9.1322366e-016       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035            lkvth0we=-1.4299999e-010  wkvth0we=-1.2000011e-011
+ pkvth0we=1.5000009e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00048769918+dcitn   lcit=1.4475774e-010+dlcitn
+ wcit=8.8758178e-011       pcit=-1.0949483e-016+dpcitn
+ voff=-0.14850048+dvoffn   lvoff=-8.3937491e-009+dlvoffn
+ wvoff=-1.0682653e-009     pvoff=1.6194193e-015+dpvoffn
+ nfactor=1.305933          lnfactor=-1.6038562e-007  wnfactor=-7.3413756e-008
+ pnfactor=4.6006229e-014   eta0=0.0092251498+deta0n  leta0=1.3110407e-007+dleta0n
+ weta0=4.7248216e-008      peta0=-2.7511725e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.020914402+du0n       lu0=5.0764788e-009+dlu0n  wu0=3.0151699e-009
+ pu0=-1.0586033e-015+dpu0n ua=-4.7450936e-010        lua=1.8421903e-017
+ wua=6.3743975e-018        pua=-6.1719657e-023       ub=3.3755544e-019
+ lub=7.394269e-025         wub=2.2747064e-025        pub=-6.2706491e-032
+ uc=4.6796853e-011         luc=7.9323958e-017        wuc=1.8651644e-017
+ puc=-2.3803623e-023       vsat=77860.433+dvsatn     lvsat=-0.00081878711+dlvsatn
+ wvsat=-0.0035518874       pvsat=2.4125667e-009+dpvsatn
+ a0=-0.10275458+da0n       la0=4.6730518e-007+dla0n  wa0=2.9650415e-007
+ pa0=-1.4364985e-013+dpa0n ags=0.3065495             lags=4.8480478e-007
+ wags=1.0570427e-007       pags=-7.7370976e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.044479894         lketa=-1.8697001e-008     wketa=-6.9594572e-009
+ pketa=6.0268161e-015      dwg=0                     dwb=0
+ pclm=0.4744185+dpclmn     lpclm=2.1458817e-007+dlpclmn
+ wpclm=3.7800547e-008      ppclm=-4.28318e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0015597345+dpdiblc2n
+ lpdiblc2=-2.5589493e-010+dlpdiblc2n                 wpdiblc2=5.1804148e-011
+ ppdiblc2=1.462308e-016+dppdiblc2n                   pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.2930198            lkt1=-7.9050298e-009
+ wkt1=1.118395e-009        pkt1=2.599352e-015        kt1l=0
+ kt2=-0.053236802          lkt2=2.1924705e-009       wkt2=1.3056516e-009
+ pkt2=-5.3137195e-016      ute=-1.3891561            lute=1.4508792e-007
+ wute=6.0707017e-008       pute=-5.4287351e-014      ua1=3.2104053e-009
+ lua1=1.3757427e-016       wua1=7.2653302e-017       pua1=-1.9943698e-022
+ ub1=-4.1547516e-018       lub1=2.9650447e-025       wub1=-7.1031093e-026
+ pub1=1.6079175e-031       uc1=-4.151591e-011        luc1=4.6792241e-017
+ wuc1=-1.519636e-018       puc1=1.8490137e-024       prt=0
+ at=139748.8               lat=-0.046532186          wat=-0.0076660769
+ pat=3.5631809e-009        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     16: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.48719013+dvthn     lvth0=-5.4580876e-009+dlvthn
+ wvth0=-6.4052624e-009+dwvthn                        pvth0=7.8603777e-016+dpvthn
+ k1=0.448                  k2=0.04626793+dk2         lk2=4.9994489e-010+dlk2
+ wk2=-5.7836793e-009       pk2=-1.6072338e-017       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035            lkvth0we=-1.4299999e-010  wkvth0we=-1.1999981e-011
+ pkvth0we=1.4999996e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00082193549+dcitn   lcit=-1.2910146e-018+dlcitn
+ wcit=-1.6405833e-010      pcit=6.5790105e-025+dpcitn
+ voff=-0.17614288+dvoffn   lvoff=3.5781717e-009+dlvoffn
+ wvoff=5.3393099e-009      pvoff=-1.1557015e-015+dpvoffn
+ nfactor=0.85596405        lnfactor=3.4495917e-008   wnfactor=7.3400719e-008
+ pnfactor=-1.7579119e-014  eta0=0.39703025+deta0n    leta0=-3.685432e-008+dleta0n
+ weta0=-3.4783194e-008     peta0=8.0160785e-015+dpeta0n
+ etab=-0.24211447          letab=-2.8535023e-008     wetab=-3.3575266e-008
+ petab=1.4541448e-014      ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.033118824+du0n       lu0=-2.092564e-010+dlu0n  wu0=3.3875357e-010
+ pu0=1.0055256e-016+dpu0n  ua=-3.335318e-010         lua=-4.263548e-017
+ wua=-1.6371084e-016       pua=1.1944258e-023        ub=1.9040785e-018
+ lub=6.0965752e-026        wub=1.5521224e-025        pub=-3.1411375e-032
+ uc=2.2466359e-010         luc=2.2898732e-018        wuc=-3.1489728e-017
+ puc=-2.0873949e-024       vsat=81637.162+dvsatn     lvsat=-0.0024544887+dlvsatn
+ wvsat=0.00038051534       pvsat=7.0944303e-010+dpvsatn
+ a0=0.85142296+da0n        la0=5.4050885e-008+dla0n  wa0=-1.0264022e-008
+ pa0=-1.0788557e-014+dpa0n ags=1.7021554             lags=-1.1963214e-007
+ wags=-9.8720178e-008      pags=1.1165252e-014       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.10549168          lketa=7.727204e-009       wketa=9.6001598e-009
+ pketa=-1.1451541e-015     dwg=0                     dwb=0
+ pclm=0.93788546+dpclmn    lpclm=1.3860637e-008+dlpclmn
+ wpclm=-4.5470853e-008     ppclm=-6.7669565e-015+dppclmn
+ pdiblc1=0                 pdiblc2=0.00072159941+dpdiblc2n
+ lpdiblc2=1.0710136e-010+dlpdiblc2n                  wpdiblc2=5.520414e-010
+ ppdiblc2=-7.0421953e-017+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.30289261           lkt1=-3.6291127e-009
+ wkt1=6.9925656e-009       pkt1=5.5248661e-017       kt1l=0
+ kt2=-0.047021566          lkt2=-4.993484e-010       wkt2=-6.5649373e-010
+ pkt2=3.1843319e-016       ute=-0.98679314           lute=-2.9175468e-008
+ wute=-9.2123567e-008      pute=1.1903575e-014       ua1=3.8640851e-009
+ lua1=-1.4553444e-016      wua1=-4.5695119e-016      pua1=2.9934724e-023
+ ub1=-3.6926465e-018       lub1=9.636675e-026        wub1=2.8897772e-025
+ pub1=4.8719324e-033       uc1=5.5143893e-011        luc1=4.9288809e-018
+ wuc1=7.1784539e-019       puc1=8.7996049e-025       prt=0
+ at=34566.399              lat=-0.0009776859         wat=0.00090202574
+ pat=-1.476644e-010        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.8V STD-VT PMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
     } 
model pch bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.459+dvthp         k1=0.493
+ k2=0.04632+dk2p           k3=-2.62                  k3b=2.309
+ w0=0                      dvt0=9.8                  dvt1=2
+ dvt2=-0.1768              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.7                  minv=-0.536
+ voffl=-4.64e-009          dvtp0=0                   dvtp1=0
+ lpe0=5.86e-008            lpeb=8e-009               web=-500
+ wec=0                     scref=1e-006              kvth0we=-0.0055034962
+ lkvth0we=0                wkvth0we=0                pkvth0we=0
+ k2we=0.0023               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.5e-007               ngate=6.7045e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-1.6805e-013          voff=-0.12508+dvoffp      nfactor=1
+ eta0=0.189                etab=-0.0159              ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.013907+du0p          ua=1.5887e-009            ub=1.478e-018
+ uc=1.058e-011             vsat=92640                a0=1.2107
+ ags=0.456+dagsp           a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.0334
+ dwg=0                     dwb=0                     pclm=0.491
+ pdiblc1=0                 pdiblc2=0.000575          pdiblcb=0
+ drout=0.5                 pvag=1.26                 delta=0.005
+ pscbe1=4.773e+008         pscbe2=1e-020             fprout=0
+ pdits=0.01699             pditsd=0                  pditsl=0
+ rsh=10.5                  rdsw=200                  rsw=369
+ rdw=369                   prwg=0                    prwb=0
+ wr=1                      alpha0=1.223e-007         alpha1=0.0143
+ beta0=19.27               agidl=0                   bgidl=1.698e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.064                noff=1.773
+ voffcv=-0.06538           kt1=-0.2635               kt1l=0
+ kt2=-0.0372               ute=-1.121                ua1=2.729e-009
+ ub1=-5.53e-018            uc1=-9.549e-011           prt=0
+ at=117200                 jss=1.76e-07              jsd=1.76e-07
+ jsws=2.71e-13             jswd=2.71e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.2                  bvd=10.2
+ xjbvs=1                   xjbvd=1                   pbs=0.86
+ pbd=0.86                  cjs=cjp                   cjd=cjp
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswp               cjswd=cjswp
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.45765            mjswgd=0.45765            tpb=0.00161
+ tcj=0.000918              tpbsw=0.00125             tcjsw=0.000886
+ tpbswg=0.00115            tcjswg=0.000723           xtis=3
+ xtid=3                    jtsswgs=6.5702e-011       jtsswgd=6.5702e-011
+ njtsswg=7.1               xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   saref=1.00e-05            sbref=1.00e-05
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=1e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=5.54e-008             lku0=5e-008               wku0=1e-008
+ pku0=1e-014               llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ lvth0=0+dlvthp            wvth0=0+dwvthp            lk2=0+dlk2p
+ wk2=0+dwk2p               lcit=0+dlcitp             wcit=0+dwcitp
+ pcit=0+dpcitp             lvoff=0+dlvoffp           wvoff=0+dwvoffp
+ pvoff=0+dpvoffp           lnfactor=0+dlnfactorp     lu0=0+dlu0p
+ wu0=0+dwu0p               lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           lpclm=0+dlpclmp           wpclm=0+dwpclmp
+ ppclm=0+dppclmp           lpdiblc2=0+dlpdiblc2p     wpdiblc2=0+dwpdiblc2p
+ ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     2: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.45586545+dvthp    lvth0=-3.1088821e-008+dlvthp
+ k1=0.493                  k2=0.045966903+dk2p       lk2=3.5020605e-009+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098244     lkvth0we=6.2763377e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=3.2262844e-005
+ lcit=-3.1998676e-010+dlcitp                         voff=-0.12431637+dvoffp
+ lvoff=-7.5737257e-009+dlvoffp                       nfactor=0.95552932
+ lnfactor=4.4106556e-007+dlnfactorp                  eta0=0.189
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013958713+du0p
+ lu0=-5.1289624e-010+dlu0p ua=1.5084622e-009         lua=7.9580829e-016
+ ub=1.6295319e-018         lub=-1.502912e-024        uc=1.3911489e-011
+ luc=-3.3042111e-017       vsat=91133.079            lvsat=0.014945822+dlvsatp
+ a0=1.2697291              la0=-5.8545782e-007       ags=0.48090104+dagsp
+ lags=-2.4697151e-007      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.0334
+ dwg=0                     dwb=0                     pclm=0.48975228
+ lpclm=1.2375039e-008+dlpclmp                        pdiblc1=0
+ pdiblc2=0.00037857935     lpdiblc2=1.9481236e-009+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.26332212
+ lkt1=-1.7642622e-009      kt1l=0                    kt2=-0.037606589
+ lkt2=4.0325994e-009       ute=-1.131673             lute=1.0585573e-007
+ ua1=2.6610234e-009        lua1=6.7420021e-016       ub1=-5.4265739e-018
+ lub1=-1.0257925e-024      uc1=-8.6086357e-011       luc1=-9.3266463e-017
+ prt=0                     at=109220.69              lat=0.079139763
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  wvth0=0+dwvthp
+ wk2=0+dwk2p               wcit=0+dwcitp             pcit=0+dpcitp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           wu0=0+dwu0p
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           wpclm=0+dwpclmp
+ ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p     ppdiblc2=0+dppdiblc2p
+ leta0=0+dleta0p           weta0=0+dweta0p           peta0=0+dpeta0p
+ fnoimod=1                 noia=noiap                noib=noibp
+ noic=noicp                em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     3: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48365805+dvthp    lvth0=-1.3357381e-011+dlvthp
+ k1=0.493                  k2=0.047992177+dk2p       lk2=1.2375613e-009+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098242     lkvth0we=6.2763261e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00064690501
+ lcit=4.394044e-010+dlcitp voff=-0.13413033+dvoffp   lvoff=3.3994535e-009+dlvoffp
+ nfactor=1.55906           lnfactor=-2.3375417e-007+dlnfactorp
+ eta0=0.189                etab=-0.0159              ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.012394969+du0p       lu0=1.2355577e-009+dlu0p  ua=2.4998028e-009
+ lua=-3.126295e-016        ub=-1.1381951e-018        lub=1.591739e-024
+ uc=-1.0779365e-010        luc=1.0303884e-016        vsat=90863.315
+ lvsat=0.01524745+dlvsatp  a0=0.40572253             la0=3.8060521e-007
+ ags=-0.10427601+dagsp     lags=4.0732665e-007       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0099231593        lketa=-2.6249925e-008     dwg=0
+ dwb=0                     pclm=0.50668563           lpclm=-6.5584741e-009+dlpclmp
+ pdiblc1=0                 pdiblc2=0.0018138207      lpdiblc2=3.4335148e-010+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.2742181
+ lkt1=1.0418757e-008       kt1l=0                    kt2=-0.032088594
+ lkt2=-2.137181e-009       ute=-1.0607134            lute=2.6514388e-008
+ ua1=3.3518052e-009        lua1=-9.817675e-017       ub1=-6.908462e-018
+ lub1=6.3113625e-025       uc1=-2.7074477e-010       luc1=1.132038e-016
+ prt=0                     at=240591.56              lat=-0.067748636
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  wvth0=0+dwvthp
+ wk2=0+dwk2p               wcit=0+dwcitp             pcit=0+dpcitp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           wu0=0+dwu0p
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           wpclm=0+dwpclmp
+ ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p     ppdiblc2=0+dppdiblc2p
+ leta0=0+dleta0p           weta0=0+dweta0p           peta0=0+dpeta0p
+ fnoimod=1                 noia=noiap                noib=noibp
+ noic=noicp                em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     4: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48927671+dvthp    lvth0=2.3359141e-009+dlvthp
+ k1=0.493                  k2=0.052087126+dk2p       lk2=-4.7461878e-010+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098244     lkvth0we=6.2763333e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0002212515
+ lcit=7.6410803e-011+dlcitp                          voff=-0.12935141+dvoffp
+ lvoff=1.4012921e-009+dlvoffp                        nfactor=1
+ eta0=0.189                etab=-0.0159              ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.014616246+du0p       lu0=3.0679707e-010+dlu0p  ua=1.8886708e-009
+ lua=-5.7102972e-017       ub=2.4383326e-018         lub=9.6321202e-026
+ uc=1.980118e-010          luc=-2.4824536e-017       vsat=142095.83
+ lvsat=-0.0061738903+dlvsatp                         a0=1.316
+ ags=0.99093795+dagsp      lags=-5.0604208e-008      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.084755589         lketa=5.0390104e-009      dwg=0
+ dwb=0                     pclm=0.50605529           lpclm=-6.2949168e-009+dlpclmp
+ pdiblc1=0                 pdiblc2=0.0028326811      lpdiblc2=-8.2654437e-011+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.24396472
+ lkt1=-2.2307852e-009      kt1l=0                    kt2=-0.0411248
+ lkt2=1.6410374e-009       ute=-0.94066639           lute=-2.3679654e-008
+ ua1=3.5769375e-009        lua1=-1.9230907e-016      ub1=-5.9135167e-018
+ lub1=2.1512974e-025       uc1=2.3119515e-011        luc1=-9.6667348e-018
+ prt=0                     at=98883.105              lat=-0.0084974967
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  wvth0=0+dwvthp
+ wk2=0+dwk2p               wcit=0+dwcitp             pcit=0+dpcitp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ wu0=0+dwu0p               wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ wpclm=0+dwpclmp           ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p
+ ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     5: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.45773606+dvthp    wvth0=-1.2736721e-008+dwvthp
+ k1=0.493                  k2=0.045916729+dk2p       wk2=4.0637598e-009+dwk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0054941521     lkvth0we=0
+ wkvth0we=-9.4160342e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-1.4511364e-005
+ wcit=1.4623101e-010+dwcitp                          voff=-0.12477236+dvoffp
+ wvoff=-3.1000974e-009+dwvoffp                       nfactor=1
+ eta0=0.189                etab=-0.01703058          wetab=1.1392858e-008
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.013868835+du0p       wu0=3.8458756e-010+dwu0p
+ ua=1.5206127e-009         wua=6.8611591e-016        ub=1.5710004e-018
+ wub=-9.3716531e-025       uc=2.2020759e-011         wuc=-1.1528853e-016
+ vsat=92640                a0=1.2385473              wa0=-2.8061731e-007
+ ags=0.47029369+dagsp      wags=-1.4403755e-007      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0334              dwg=0                     dwb=0
+ pclm=0.491                pdiblc1=0                 pdiblc2=0.00062941761
+ wpdiblc2=-5.4836629e-010+dwpdiblc2p                 pdiblcb=0
+ drout=0.5                 pvag=1.26                 delta=0.005
+ pscbe1=4.773e+008         pscbe2=1e-020             fprout=0
+ pdits=0.01699             pditsd=0                  pditsl=0
+ rsh=10.5                  rdsw=200                  rsw=369
+ rdw=369                   prwg=0                    prwb=0
+ wr=1                      alpha0=1.223e-007         alpha1=0.0143
+ beta0=19.27               agidl=0                   bgidl=1.698e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.064                noff=1.773
+ voffcv=-0.06538           kt1=-0.26415301           wkt1=6.5803955e-009
+ kt1l=0                    kt2=-0.036925735          wkt2=-2.7637661e-009
+ ute=-1.1214353            wute=4.3869303e-009       ua1=2.7493159e-009
+ wua1=-2.0472342e-016      ub1=-5.5369655e-018       wub1=7.0190885e-026
+ uc1=-9.6938234e-011       wuc1=1.4593852e-017       prt=0
+ at=118114.22              wat=-0.0092125537         jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthp            lk2=0+dlk2p
+ lcit=0+dlcitp             pcit=0+dpcitp             lvoff=0+dlvoffp
+ pvoff=0+dpvoffp           lnfactor=0+dlnfactorp     lu0=0+dlu0p
+ lvsat=0+dlvsatp           wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ lpclm=0+dlpclmp           wpclm=0+dwpclmp           ppclm=0+dppclmp
+ lpdiblc2=0+dlpdiblc2p     ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     6: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.45427553+dvthp    lvth0=-3.4321969e-008+dlvthp
+ wvth0=-1.6021661e-008+dwvthp                        pvth0=3.2580433e-014
+ k1=0.493                  k2=0.045549508+dk2p       lk2=3.6421392e-009+dlk2p
+ wk2=4.2060824e-009+dwk2p  pk2=-1.411573e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055           lkvth0we=5.8000061e-011   wkvth0we=-9.8999962e-011
+ pkvth0we=4.7999933e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=2.0589458e-005        lcit=-3.4813417e-010+dlcitp
+ wcit=1.1763271e-010+dwcitp                          pcit=2.8364141e-016+dpcitp
+ voff=-0.12396872+dvoffp   lvoff=-7.9705544e-009+dlvoffp
+ wvoff=-3.503283e-009+dwvoffp                        pvoff=3.9988427e-015+dpvoffp
+ nfactor=0.94907602        lnfactor=5.0507019e-007+dlnfactorp
+ wnfactor=6.5029928e-008   pnfactor=-6.4497463e-013  eta0=0.189
+ etab=-0.017174231         letab=1.424743e-009       wetab=1.2840424e-008
+ petab=-1.4357135e-014     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013937714+du0p
+ lu0=-6.8314854e-010+dlu0p wu0=2.1160795e-010+dwu0p  pu0=1.7156325e-015
+ ua=1.4324742e-009         lua=8.7416824e-016        wua=7.6573112e-016
+ pua=-7.8963322e-022       ub=1.7521381e-018         lub=-1.7965451e-024
+ wub=-1.2355022e-024       pub=2.9589409e-030        uc=2.621865e-011
+ luc=-4.163519e-017        wuc=-1.2401926e-016       puc=8.6592451e-023
+ vsat=91013.97             lvsat=0.016127164+dlvsatp wvsat=0.0012002667+dwvsatp
+ pvsat=-1.1904389e-008+dpvsatp                       a0=1.3116221
+ la0=-7.2476481e-007       wa0=-4.2215588e-007       pa0=1.4037965e-012
+ ags=0.50246724+dagsp      lags=-3.1910107e-007      wags=-2.1732256e-007
+ pags=7.2684955e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.033780265
+ lketa=3.7715184e-009      wketa=3.8319349e-009      pketa=-3.8005591e-014
+ dwg=0                     dwb=0                     pclm=0.48957122
+ lpclm=1.4170826e-008+dlpclmp                        wpclm=1.824554e-009+dwpclmp
+ ppclm=-1.8096145e-014+dppclmp                       pdiblc1=0
+ pdiblc2=0.00044934226     lpdiblc2=1.786009e-009+dlpdiblc2p
+ wpdiblc2=-7.1307781e-010+dwpdiblc2p                 ppdiblc2=1.6336286e-015+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.26387372
+ lkt1=-2.7700492e-009      wkt1=5.5584966e-009       pkt1=1.0135316e-014
+ kt1l=0                    kt2=-0.037379341          lkt2=4.4989188e-009
+ wkt2=-2.2899766e-009      pkt2=-4.6991009e-015      ute=-1.1309596
+ lute=9.4462912e-008       wute=-7.1883949e-009      pute=1.1480547e-013
+ ua1=2.6910192e-009        lua1=5.7819327e-016       wua1=-3.0226831e-016
+ pua1=9.6746194e-022       ub1=-5.4458191e-018       lub1=-9.0400081e-025
+ wub1=1.9393355e-025       pub1=-1.2272946e-030      uc1=-8.7508409e-011
+ luc1=-9.3526137e-017      wuc1=1.4330018e-017       puc1=2.6167395e-024
+ prt=0                     at=110619.82              lat=0.074330274
+ wat=-0.014099086          pat=4.8465218e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ saref=1.00e-05            sbref=1.00e-05            rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     7: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48524403+dvthp    lvth0=3.0453007e-010+dlvthp
+ wvth0=1.5981866e-008+dwvthp                         pvth0=-3.2033519e-015
+ k1=0.493                  k2=0.047324832+dk2p       lk2=1.6571146e-009+dlk2p
+ wk2=6.7248331e-009+dwk2p  pk2=-4.2278385e-015       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999931e-011   wkvth0we=-9.9000092e-011
+ pkvth0we=4.8000079e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00076158258        lcit=5.2642803e-010+dlcitp
+ wcit=1.1556058e-009+dwcitp                          pcit=-8.769371e-016+dpcitp
+ voff=-0.13429534+dvoffp   lvoff=3.5758422e-009+dlvoffp
+ wvoff=1.6628104e-009+dwvoffp                        pvoff=-1.7774696e-015+dpvoffp
+ nfactor=1.6401872         lnfactor=-2.6767508e-007+dlnfactorp
+ wnfactor=-8.1751909e-007  pnfactor=3.4182108e-013   eta0=0.18719796
+ leta0=2.0149025e-009+dleta0p                        weta0=1.8159207e-008+dweta0p
+ peta0=-2.0304172e-014+dpeta0p                       etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.012118209+du0p       lu0=1.3512765e-009+dlu0p
+ wu0=2.788908e-009+dwu0p   pu0=-1.1660982e-015       ua=2.6075928e-009
+ lua=-4.3975541e-016       wua=-1.0861998e-015       pua=1.2810478e-021
+ ub=-1.5190313e-018        lub=1.8610149e-024        wub=3.8376866e-024
+ pub=-2.713493e-030        uc=-1.2195413e-010        luc=1.2403976e-016
+ wuc=1.4269519e-016        puc=-2.1162632e-022       vsat=88037.344
+ lvsat=0.019455389+dlvsatp wvsat=0.028477307+dwvsatp pvsat=-4.2403394e-008+dpvsatp
+ a0=0.25681324             la0=4.546381e-007         wa0=1.5005589e-006
+ pa0=-7.460294e-013        ags=-0.1823676+dagsp      lags=4.4662646e-007
+ wags=7.8692894e-007       pags=-3.9602414e-013      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0054443204        lketa=-2.7911469e-008     wketa=-4.513326e-008
+ pketa=1.6743373e-014      dwg=0                     dwb=0
+ pclm=0.52300633           lpclm=-2.3213644e-008+dlpclmp
+ wpclm=-1.6446377e-007+dwpclmp                       ppclm=1.6783415e-013+dppclmp
+ pdiblc1=0                 pdiblc2=0.0017101591      lpdiblc2=3.7626446e-010+dlpdiblc2p
+ wpdiblc2=1.0445982e-009+dwpdiblc2p                  ppdiblc2=-3.3166411e-016+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27670071
+ lkt1=1.1572068e-008       wkt1=2.501726e-008        pkt1=-1.1621917e-014
+ kt1l=0                    kt2=-0.030643381          lkt2=-3.0326932e-009
+ wkt2=-1.4563415e-008      pkt2=9.0240766e-015       ute=-1.0722609
+ lute=2.88307e-008         wute=1.1636448e-007       pute=-2.3341477e-014
+ ua1=3.2818079e-009        lua1=-8.2379294e-017      wua1=7.0536317e-016
+ pua1=-1.5919096e-022      ub1=-6.8509395e-018       lub1=6.670924e-025
+ wub1=-5.7965464e-025      pub1=-3.6233015e-031      uc1=-2.7980053e-010
+ luc1=1.2147953e-016       wuc1=9.1254954e-017       puc1=-8.339457e-023
+ prt=0                     at=239036.27              lat=-0.069254726
+ wat=0.01567263            pat=1.5176866e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     8: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48984522+dvthp    lvth0=2.2283804e-009+dlvthp
+ wvth0=5.7289033e-009+dwvthp                         pvth0=1.083617e-015
+ k1=0.493                  k2=0.052782109+dk2p       lk2=-6.2468224e-010+dlk2p
+ wk2=-7.0033501e-009+dwk2p pk2=1.5121895e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055000001     lkvth0we=5.8000013e-011   wkvth0we=-9.8999853e-011
+ pkvth0we=4.7999979e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00033001112         lcit=7.0010874e-011+dlcitp
+ wcit=-1.0959707e-009+dwcitp                         pcit=6.4492087e-017+dpcitp
+ voff=-0.12851612+dvoffp   lvoff=1.1594343e-009+dlvoffp
+ wvoff=-8.4172398e-009+dwvoffp                       pvoff=2.437201e-015+dpvoffp
+ nfactor=1.0075642         lnfactor=-3.1627557e-009+dlnfactorp
+ wnfactor=-7.6224743e-008  pnfactor=3.1871089e-014   eta0=0.19294197
+ leta0=-3.8678642e-010+dleta0p                       weta0=-3.9723265e-008+dweta0p
+ peta0=3.8976468e-015+dpeta0p                        etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.014489167+du0p       lu0=3.5993136e-010+dlu0p
+ wu0=1.2805757e-009+dwu0p  pu0=-5.354343e-016        ua=1.6733617e-009
+ lua=-4.9134688e-017       wua=2.1696697e-015        pua=-8.0296397e-023
+ ub=2.7179937e-018         lub=8.9429929e-026        wub=-2.818145e-024
+ pub=6.9443354e-032        uc=2.4549014e-010         luc=-2.9596037e-017
+ wuc=-4.7843924e-016       puc=4.8082413e-023        vsat=151703.6
+ lvsat=-0.0071647445+dlvsatp                         wvsat=-0.096817419+dwvsatp
+ pvsat=9.9848373e-009+dpvsatp                        a0=1.3527842
+ la0=-3.6092624e-009       wa0=-3.7067404e-007       pa0=3.6370537e-014
+ ags=1.011927+dagsp        lags=-5.2731998e-008      wags=-2.1150664e-007
+ pags=2.1441744e-014       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.084095749
+ lketa=4.9742669e-009      wketa=-6.6492045e-009     pketa=6.5241995e-016
+ dwg=0                     dwb=0                     pclm=0.47402209
+ lpclm=-2.7323516e-009+dlpclmp                       wpclm=3.2279855e-007+dwpclmp
+ ppclm=-3.589997e-014+dppclmp                        pdiblc1=0
+ pdiblc2=0.002799807       lpdiblc2=-7.9339125e-011+dlpdiblc2p
+ wpdiblc2=3.3127257e-010+dwpdiblc2p                  ppdiblc2=-3.3408401e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.24300823
+ lkt1=-2.5154332e-009      wkt1=-9.638616e-009       pkt1=2.868398e-015
+ kt1l=0                    kt2=-0.04246208           lkt2=1.9089414e-009
+ wkt2=1.3475773e-008       pkt2=-2.6996687e-015      ute=-0.93501183
+ lute=-2.8555879e-008      wute=-5.6980956e-008      pute=4.9137717e-014
+ ua1=3.63091e-009          lua1=-2.2834588e-016      wua1=-5.4388079e-016
+ pua1=3.6314292e-022       ub1=-5.8435059e-018       lub1=2.4586429e-025
+ wub1=-7.0549913e-025      pub1=-3.0971205e-031      uc1=3.9003709e-011
+ luc1=-1.1818897e-017      wuc1=-1.6006502e-016      puc1=2.1687339e-023
+ prt=0                     at=92130.159              lat=-0.0078303414
+ wat=0.068049435           pat=-6.7229236e-009       jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     9: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.46311873+dvthp    wvth0=-5.8630536e-009+dwvthp
+ k1=0.493                  k2=0.046955033+dk2p       wk2=2.737846e-009+dwk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.005494152      lkvth0we=0
+ wkvth0we=-9.4160431e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00018242858
+ wcit=-1.0526129e-010+dwcitp                         voff=-0.11884174+dvoffp
+ wvoff=-1.0673494e-008+dwvoffp                       nfactor=1
+ eta0=0.189                etab=-0.00168699          wetab=-8.2009068e-009
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.014927519+du0p       wu0=-9.6735122e-010+dwu0p
+ ua=2.1980286e-009         wua=-1.7894419e-016       ub=1.2778079e-018
+ wub=-5.6275841e-025       uc=-3.7398743e-011        wuc=-3.9409825e-017
+ vsat=92640                a0=0.86597743             wa0=1.9515442e-007
+ ags=0.38476737+dagsp      wags=-3.4820433e-008      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.038840286         wketa=6.9472449e-009      dwg=0
+ dwb=0                     pclm=0.55980313           wpclm=-8.7861595e-008+dwpclmp
+ pdiblc1=0                 pdiblc2=0.00012993571     wpdiblc2=8.9472093e-011+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27152914
+ wkt1=1.5999715e-008       kt1l=0                    kt2=-0.043285614
+ wkt2=5.3577994e-009       ute=-1.0998657            wute=-2.3157483e-008
+ ua1=2.9459157e-009        wua1=-4.5578137e-016      ub1=-6.2255057e-018
+ wub1=9.494568e-025        uc1=-1.3602223e-010       wuc1=6.4504116e-017
+ prt=0                     at=129248.6               wat=-0.023431166
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lvth0=0+dlvthp
+ lk2=0+dlk2p               lcit=0+dlcitp             pcit=0+dpcitp
+ lvoff=0+dlvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ lu0=0+dlu0p               lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           lpclm=0+dlpclmp           ppclm=0+dppclmp
+ lpdiblc2=0+dlpdiblc2p     ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     10: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.46278043+dvthp    lvth0=-3.3552487e-009+dlvthp
+ wvth0=-5.1608974e-009+dwvthp                        pvth0=-6.9640692e-015
+ k1=0.493                  k2=0.046549495+dk2p       lk2=4.0221758e-009+dlk2p
+ wk2=2.9291e-009+dwk2p     pk2=-1.8968798e-015       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999947e-011   wkvth0we=-9.9000065e-011
+ pkvth0we=4.8000079e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00022655438         lcit=-4.3764506e-010+dlcitp
+ wcit=-1.453845e-010+dwcitp                          pcit=3.9794682e-016+dpcitp
+ voff=-0.11772334+dvoffp   lvoff=-1.1092421e-008+dlvoffp
+ wvoff=-1.1478633e-008+dwvoffp                       pvoff=7.985466e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=0.00011890213
+ letab=-1.7911055e-008     wetab=-9.2429065e-009     petab=1.0334679e-014
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.015067159+du0p       lu0=-1.3849693e-009+dlu0p
+ wu0=-1.2306932e-009+dwu0p pu0=2.6118576e-015        ua=2.2366778e-009
+ lua=-3.8332756e-016       wua=-2.6123689e-016       pua=8.1618891e-022
+ ub=1.2299065e-018         lub=4.7509189e-025        wub=-5.6861239e-025
+ pub=5.806044e-032         uc=-4.7868646e-011        luc=1.0384176e-016
+ wuc=-2.9409784e-017       puc=-9.918161e-023        vsat=91765.362
+ lvsat=0.0086747694+dlvsatp                          wvsat=0.00024073926+dwvsatp
+ pvsat=-2.3876809e-009+dpvsatp                       a0=0.81293492
+ la0=5.2608194e-007        wa0=2.1466768e-007        pa0=-1.935348e-013
+ ags=0.36180321+dagsp      lags=2.2776134e-007       wags=-3.7694593e-008
+ pags=2.8506256e-014       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.036820149
+ lketa=-2.0035963e-008     wketa=7.7138657e-009      pketa=-7.603437e-015
+ dwg=0                     dwb=0                     pclm=0.5726591
+ lpclm=-1.275071e-007+dlpclmp                        wpclm=-1.0427868e-007+dwpclmp
+ ppclm=1.6282657e-013+dppclmp                        pdiblc1=0
+ pdiblc2=-0.00019470709    lpdiblc2=3.2198463e-009+dlpdiblc2p
+ wpdiblc2=1.093732e-010+dwpdiblc2p                   ppdiblc2=-1.9738162e-016+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27417616
+ lkt1=2.6253482e-008       wkt1=1.8714719e-008       pkt1=-2.6927734e-014
+ kt1l=0                    kt2=-0.04427938           lkt2=9.856285e-009
+ wkt2=6.5213725e-009       pkt2=-1.1540457e-014      ute=-1.1461354
+ lute=4.5890817e-007       wute=1.2191064e-008       pute=-3.5059113e-013
+ ua1=2.6829352e-009        lua1=2.6082727e-015       wua1=-2.9194493e-016
+ pua1=-1.6249495e-021      ub1=-5.9918994e-018       lub1=-2.3169354e-024
+ wub1=8.9127814e-025       pub1=5.7702287e-031       uc1=-1.2181791e-010
+ luc1=-1.4088017e-016      wuc1=5.8143249e-017       puc1=6.3087841e-023
+ prt=0                     at=112582.07              lat=0.1653007
+ wat=-0.016604872          pat=-6.7704012e-008       jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     11: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.46431722+dvthp    lvth0=-1.6369375e-009+dlvthp
+ wvth0=-1.0741668e-008+dwvthp                        pvth0=-7.2409777e-016
+ k1=0.493                  k2=0.052094928+dk2p       lk2=-2.1782845e-009+dlk2p
+ wk2=6.3341977e-010+dwk2p  pk2=6.6996619e-016        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055           lkvth0we=5.8000032e-011   wkvth0we=-9.8999949e-011
+ pkvth0we=4.7999949e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00026308099         lcit=-4.7848619e-010+dlcitp
+ wcit=-1.5288955e-010+dwcitp                         pcit=4.0633836e-016+dpcitp
+ voff=-0.13306828+dvoffp   lvoff=6.065062e-009+dlvoffp
+ wvoff=9.5856942e-011+dwvoffp                        pvoff=-4.9562032e-015+dpvoffp
+ nfactor=1                 eta0=0.21165428           leta0=-2.5330203e-008+dleta0p
+ weta0=-1.3071519e-008+dweta0p                       peta0=1.4615527e-014+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013242673+du0p
+ lu0=6.5502497e-010+dlu0p  wu0=1.3529673e-009+dwu0p  pu0=-2.7698497e-016
+ ua=1.1103413e-009         lua=8.7605175e-016        wua=8.2579035e-016
+ pua=-3.9923799e-022       ub=2.2473151e-018         lub=-6.6249308e-025
+ wub=-9.7193782e-025       pub=5.0902668e-031        uc=1.0291619e-010
+ luc=-6.4753787e-017       wuc=-1.4446421e-016       puc=2.9463046e-023
+ vsat=116536.53            lvsat=-0.019022369+dlvsatp
+ wvsat=-0.0079161528+dwvsatp                         pvsat=6.7327033e-009+dpvsatp
+ a0=1.4753889              la0=-2.1462115e-007       wa0=-5.556223e-008
+ pa0=1.0861467e-013        ags=0.41986894+dagsp      lags=1.6283688e-007
+ wags=1.7872885e-008       pags=-3.3624851e-014      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.042199189         lketa=-1.402155e-008      wketa=1.8027073e-009
+ pketa=-9.9405267e-016     dwg=0                     dwb=0
+ pclm=0.32811765           lpclm=1.4591959e-007+dlpclmp
+ wpclm=8.4409083e-008+dwpclmp                        ppclm=-4.8148987e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.0025703201      lpdiblc2=1.2821407e-010+dlpdiblc2p
+ wpdiblc2=-5.3827398e-011+dwpdiblc2p                 ppdiblc2=-1.490376e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.25078907
+ lkt1=1.0390134e-010       wkt1=-8.0719106e-009      pkt1=3.0229325e-015
+ kt1l=0                    kt2=-0.038082468          lkt2=2.9273941e-009
+ wkt2=-5.0637012e-009      pkt2=1.4130452e-015       ute=-0.36258271
+ lute=-4.1719775e-007      wute=-7.8989456e-007      pute=5.4623685e-013
+ ua1=8.1928905e-009        lua1=-3.5525186e-015      wua1=-5.5660894e-015
+ pua1=4.2721769e-021       ub1=-1.1065167e-017       lub1=3.3555871e-024
+ wub1=4.8019145e-024       pub1=-3.7955379e-030      uc1=-4.4391633e-010
+ luc1=2.1926452e-016       wuc1=3.0083083e-016       puc1=-2.08266e-022
+ prt=0                     at=343683.44              lat=-0.093098368
+ wat=-0.1179618            pat=4.5625197e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     12: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.47709758+dvthp    lvth0=3.7067884e-009+dlvthp
+ wvth0=-1.0549828e-008+dwvthp                        pvth0=-8.0430993e-016
+ k1=0.493                  k2=0.044959723+dk2p       lk2=8.0508781e-010+dlk2p
+ wk2=2.9858379e-009+dwk2p  pk2=-3.1362689e-016       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999984e-011   wkvth0we=-9.9000108e-011
+ pkvth0we=4.8000016e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.001416708          lcit=2.2386717e-010+dlcitp
+ wcit=1.1345896e-009+dwcitp                          pcit=-1.319824e-016+dpcitp
+ voff=-0.12335005+dvoffp-0.0037911991                lvoff=2.0016755e-009+dlvoffp+1.5851762e-09
+ wvoff=-1.5014308e-008+dwvoffp+4.8413613e-09         pvoff=1.3616589e-015+dpvoffp-2.02427e-15
+ nfactor=0.90490683        lnfactor=3.9760358e-008+dlnfactorp
+ wnfactor=5.4868761e-008   pnfactor=-2.2941726e-014  eta0=0.13308213
+ leta0=7.5223835e-009+dleta0p                        weta0=3.6717752e-008+dweta0p
+ peta0=-6.2023632e-015+dpeta0p                       etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.015670806+du0p       lu0=-3.6022584e-010+dlu0p
+ wu0=-2.2837633e-010+dwu0p pu0=3.8420644e-016        ua=3.9336567e-009
+ lua=-3.0443287e-016       wua=-7.1672704e-016       pua=2.4571938e-022
+ ub=1.323592e-019          lub=2.2181229e-025        wub=4.8371032e-025
+ pub=-9.9608927e-032       uc=-1.158162e-010         luc=2.6702601e-017
+ wuc=-1.7051042e-017       puc=-2.3810948e-023       vsat=70977.126
+ lvsat=2.6928398e-005+dlvsatp                        wvsat=0.0062702822+dwvsatp
+ pvsat=8.010711e-010+dpvsatp                         a0=0.92737249
+ la0=1.4515488e-008        wa0=1.7257667e-007        pa0=1.322523e-014
+ ags=0.84053845+dagsp      lags=-1.3053452e-008      wags=7.3565455e-009
+ pags=-2.9227759e-014      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.088714584
+ lketa=5.427467e-009       wketa=-7.5095217e-010     pketa=7.3683427e-017
+ dwg=0                     dwb=0                     pclm=0.7535018
+ lpclm=-3.1942034e-008+dlpclmp                       wpclm=-3.4097044e-008+dwpclmp
+ ppclm=1.4007948e-015+dppclmp                        pdiblc1=0
+ pdiblc2=0.0032170396      lpdiblc2=-1.421923e-010+dlpdiblc2p
+ wpdiblc2=-2.0153347e-010+dwpdiblc2p                 ppdiblc2=4.6855102e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.24355272
+ lkt1=-2.9217608e-009      wkt1=-8.9433015e-009      pkt1=3.3872784e-015
+ kt1l=0                    kt2=-0.029377359          lkt2=-7.1238605e-010
+ wkt2=-3.2334162e-009      pkt2=6.4776639e-016       ute=-1.5461709
+ lute=7.7684143e-008       wute=7.2346917e-007       pute=-8.6530791e-014
+ ua1=-2.1574544e-009       lua1=7.7516763e-016       wua1=6.8478606e-015
+ pua1=-9.1834382e-022      ub1=-1.293409e-018        lub1=-7.3018056e-025
+ wub1=-6.5159729e-024      pub1=9.3669722e-031       uc1=1.7682462e-010
+ luc1=-4.027969e-017       wuc1=-3.3606233e-016      puc1=5.8031772e-023
+ prt=0                     at=153970.35              lat=-0.013775532
+ wat=-0.010920492          pat=8.6908522e-010        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     13: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.47328+dvthp       k1=0.493
+ k2=0.061901123+dk2p       wk2=-5.8860477e-009+dwk2p k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054941522     lkvth0we=0                wkvth0we=-9.4160364e-011
+ pkvth0we=0                k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-1.0651293e-011       wcit=2.5462971e-018+dwcitp
+ voff=-0.13842523+dvoffp   wvoff=6.2617529e-010+dwvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.013251+du0p          ua=1.7655106e-009
+ wua=7.0618658e-017        ub=3.5625174e-019         wub=-3.1020525e-026
+ uc=-1.057e-010            vsat=92640                a0=1.1079077
+ wa0=5.5560633e-008        ags=0.21935981+dagsp      wags=6.0619732e-008
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.042649809         wketa=9.1453398e-009
+ dwg=0                     dwb=0                     pclm=0.4667351
+ wpclm=-3.4161341e-008+dwpclmp                       pdiblc1=0
+ pdiblc2=0.00027208065     wpdiblc2=7.4544677e-012+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.2438
+ kt1l=0                    kt2=-0.034                ute=-1.14
+ ua1=2.156e-009            ub1=-4.58e-018            uc1=-2.4230005e-011
+ wuc1=1.4908935e-024       prt=0                     at=88639.993
+ wat=1.4908936e-009        jss=1.76e-07              jsd=1.76e-07
+ jsws=2.71e-13             jswd=2.71e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.2                  bvd=10.2
+ xjbvs=1                   xjbvd=1                   pbs=0.86
+ pbd=0.86                  cjs=cjp                   cjd=cjp
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswp               cjswd=cjswp
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.45765            mjswgd=0.45765            tpb=0.00161
+ tcj=0.000918              tpbsw=0.00125             tcjsw=0.000886
+ tpbswg=0.00115            tcjswg=0.000723           xtis=3
+ xtid=3                    jtsswgs=6.5702e-011       jtsswgd=6.5702e-011
+ njtsswg=7.1               xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1.00e-05            sbref=1.00e-05            wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=1e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=5.54e-008             lku0=5e-008               wku0=1e-008
+ pku0=1e-014               llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ lvth0=0+dlvthp            wvth0=0+dwvthp            lk2=0+dlk2p
+ lcit=0+dlcitp             pcit=0+dpcitp             lvoff=0+dlvoffp
+ pvoff=0+dpvoffp           lnfactor=0+dlnfactorp     lu0=0+dlu0p
+ wu0=0+dwu0p               lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           lpclm=0+dlpclmp           ppclm=0+dppclmp
+ lpdiblc2=0+dlpdiblc2p     ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     14: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.47105506+dvthp    lvth0=-2.2067262e-008+dlvthp
+ wvth0=-3.8644042e-010+dwvthp                        pvth0=3.8327625e-015
+ k1=0.493                  k2=0.062202518+dk2p       lk2=-2.9892741e-009+dlk2p
+ wk2=-6.1026943e-009+dwk2p pk2=2.1487268e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055000001     lkvth0we=5.8000146e-011   wkvth0we=-9.8999987e-011
+ pkvth0we=4.7999964e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-4.7298785e-005       lcit=4.6911492e-010+dlcitp
+ wcit=1.2628776e-011+dwcitp                          pcit=-1.2525369e-016+dpcitp
+ voff=-0.1381244+dvoffp    lvoff=-2.9836357e-009+dlvoffp
+ wvoff=2.9277571e-010+dwvoffp                        pvoff=3.306697e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.012761991+du0p       lu0=4.8500463e-009+dlu0p
+ wu0=9.9388435e-011+dwu0p  pu0=-9.8574643e-016       ua=1.7151175e-009
+ lua=4.9980573e-016        wua=3.9703424e-017        pua=3.06621e-022
+ ub=8.0525916e-020         lub=2.7346818e-024        wub=9.4580189e-026
+ pub=-1.245723e-030        uc=-1.1180683e-010        luc=6.0568261e-017
+ wuc=7.4825474e-018        puc=-7.4212803e-023       vsat=91788.622
+ lvsat=0.008444068+dlvsatp wvsat=0.00022731789+dwvsatp
+ pvsat=-2.2545662e-009+dpvsatp                       a0=1.0721262
+ la0=3.5488541e-007        wa0=6.5114299e-008        pa0=-9.4754405e-014
+ ags=0.16739788+dagsp      lags=5.1536466e-007       wags=7.4477283e-008
+ pags=-1.3744086e-013      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.037358179
+ lketa=-5.2483026e-008     wketa=8.024309e-009       pketa=1.1118518e-014
+ dwg=0                     dwb=0                     pclm=0.46510904
+ lpclm=1.6127471e-008+dlpclmp                        wpclm=-4.2222286e-008+dwpclmp
+ ppclm=7.9949421e-014+dppclmp                        pdiblc1=0
+ pdiblc2=-9.1744484e-006   lpdiblc2=2.7895218e-009+dlpdiblc2p
+ wpdiblc2=2.320872e-012+dwpdiblc2p                   ppdiblc2=5.0915619e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.23976087
+ lkt1=-4.0060542e-008      wkt1=-1.1429039e-009      pkt1=1.1335458e-014
+ kt1l=0                    kt2=-0.032096224          lkt2=-1.8881875e-008
+ wkt2=-5.0830813e-010      pkt2=5.0414611e-015       ute=-1.0845709
+ lute=-5.4975265e-007      wute=-2.3331656e-008      pute=2.3140617e-013
+ ua1=2.40634e-009          lua1=-2.4829023e-015      wua1=-1.3234953e-016
+ pua1=1.3126585e-021       ub1=-4.5776695e-018       lub1=-2.3114274e-026
+ wub1=7.5267481e-026       pub1=-7.4651191e-031      uc1=-2.9436795e-011
+ luc1=5.1641576e-017       wuc1=4.8393468e-018       puc1=-4.7997207e-023
+ prt=0                     at=75410.479              lat=0.13121191
+ wat=0.0048431353          pat=-4.8034783e-008       jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     15: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.49135323+dvthp    lvth0=6.2852941e-010+dlvthp
+ wvth0=4.8581081e-009+dwvthp                         pvth0=-2.0312722e-015
+ k1=0.493                  k2=0.060186145+dk2p       lk2=-7.3472705e-010+dlk2p
+ wk2=-4.0352121e-009+dwk2p pk2=-1.6296644e-016       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999998     lkvth0we=5.7999904e-011   wkvth0we=-9.900004e-011
+ pkvth0we=4.8000024e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00014052712         lcit=2.5910302e-010+dlcitp
+ wcit=-8.2175962e-011+dwcitp                         pcit=-1.9250614e-017+dpcitp
+ voff=-0.14099926+dvoffp   lvoff=2.3080262e-010+dlvoffp
+ wvoff=4.6720307e-009+dwvoffp                        pvoff=-1.5898356e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.016605688+du0p       lu0=5.5233201e-010+dlu0p
+ wu0=-5.8749248e-010+dwu0p pu0=-2.1773114e-016       ua=2.072246e-009
+ lua=1.0049318e-016        wua=2.7077137e-016        pua=4.825931e-023
+ ub=1.6993676e-018         lub=9.2462252e-025        wub=-6.5577213e-025
+ pub=-4.0673902e-031       uc=-1.0676735e-010        luc=5.4933522e-017
+ wuc=-2.3476805e-017       puc=-3.9596531e-023       vsat=104264.2
+ lvsat=-0.0055051196+dlvsatp                         wvsat=-0.00083501563+dwvsatp
+ pvsat=-1.0667498e-009+dpvsatp                       a0=1.480818
+ la0=-1.0208098e-007       wa0=-5.8694769e-008       pa0=4.367899e-014
+ ags=0.38698297+dagsp      lags=2.6984217e-007       wags=3.6848087e-008
+ pags=-9.5366901e-014      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.06312954
+ lketa=-2.3667551e-008     wketa=1.387952e-008       pketa=4.57169e-015
+ dwg=0                     dwb=0                     pclm=0.50323683
+ lpclm=-2.6503974e-008+dlpclmp                       wpclm=-1.6634681e-008+dwpclmp
+ ppclm=5.1339409e-014+dppclmp                        pdiblc1=0
+ pdiblc2=0.0023486111      lpdiblc2=1.5323458e-010+dlpdiblc2p
+ wpdiblc2=7.4098693e-011+dwpdiblc2p                  ppdiblc2=-2.9340598e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27321686
+ lkt1=-2.6527328e-009      wkt1=4.8689261e-009       pkt1=4.6135103e-015
+ kt1l=0                    kt2=-0.061431514          lkt2=1.3918499e-008
+ wkt2=8.4086983e-009       pkt2=-4.9288222e-015      ute=-2.5510369
+ lute=1.0899324e-006       wute=4.7284353e-007       pute=-3.2337723e-013
+ ua1=-7.2851481e-009       lua1=8.3533443e-015       wua1=3.3647389e-015
+ pua1=-2.597506e-021       ub1=1.8185611e-018        lub1=-7.1748676e-024
+ wub1=-2.6319968e-024      pub1=2.2805345e-030       uc1=3.6526313e-010
+ luc1=-3.896803e-016       wuc1=-1.6606572e-016      puc1=1.4309516e-022
+ prt=0                     at=244763.69              lat=-0.058145303
+ wat=-0.060885106          pat=2.5457278e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     16: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.49241047+dvthp    lvth0=1.0705825e-009+dlvthp
+ wvth0=-1.7142946e-009+dwvthp                        pvth0=7.1678087e-016
+ k1=0.493                  k2=0.056440429+dk2p       lk2=8.314315e-010+dlk2p
+ wk2=-3.6385299e-009+dwk2p pk2=-3.2882721e-016       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055000001     lkvth0we=5.8000025e-011   wkvth0we=-9.8999965e-011
+ pkvth0we=4.7999992e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00081359137         lcit=-2.2318605e-011+dlcitp
+ wcit=-1.5229316e-010+dwcitp                         pcit=1.0066789e-017+dpcitp
+ voff=-0.15167884+dvoffp+0.0085607722                lvoff=4.6961502e-009+dlvoffp-3.5794301e-09
+ wvoff=1.3314046e-009+dwvoffp-2.2857262e-09          pvoff=-1.9305298e-016+dpvoffp+9.5570783e-16
+ nfactor=1                 eta0=0.19443335           leta0=-2.2717904e-009+dleta0p
+ weta0=1.3181021e-009+dweta0p                        peta0=-5.5112485e-016+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016704734+du0p
+ lu0=5.1091887e-010+dlu0p  wu0=-8.2495321e-010+dwu0p pu0=-1.1844406e-016
+ ua=1.8777014e-009         lua=1.8183616e-016        wua=4.6955918e-016
+ pua=-3.485785e-023        ub=3.5667728e-018         lub=1.4382307e-025
+ wub=-1.4979463e-024       pub=-5.4609145e-032       uc=6.1745049e-011
+ luc=-1.5524884e-017       wuc=-1.1950388e-016       puc=5.5431054e-025
+ vsat=84312.007            lvsat=0.0028372891+dlvsatp
+ wvsat=-0.0014239441+dwvsatp                         pvsat=-8.2050703e-010+dpvsatp
+ a0=1.2131375              la0=9.8415509e-009        wa0=7.6902339e-009
+ pa0=1.5922092e-014        ags=1.320679+dagsp        lags=-1.2055482e-007
+ wags=-2.6968456e-007      pags=3.280053e-014        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.14103023          lketa=8.9042862e-009      wketa=2.9435177e-008
+ pketa=-1.9324412e-015     dwg=0                     dwb=0
+ pclm=0.43394723           lpclm=2.4673915e-009+dlpclmp
+ wpclm=1.5028595e-007+dwpclmp                        ppclm=-1.8453444e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.0028285795      lpdiblc2=-4.7449802e-011+dlpdiblc2p
+ wpdiblc2=2.2608022e-011+dwpdiblc2p                  ppdiblc2=-7.8113186e-018+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.29620025
+ lkt1=6.9570804e-009       wkt1=2.1434322e-008       pkt1=-2.3128129e-015
+ kt1l=0                    kt2=-0.032837576          lkt2=1.9628015e-009
+ wkt2=-1.2368709e-009      pkt2=-8.958168e-016       ute=0.25467603
+ lute=-8.319233e-008       wute=-3.1561951e-007      pute=6.294934e-015
+ ua1=1.4789977e-008        lua1=-8.7670686e-016      wua1=-2.9308072e-015
+ pua1=3.4787759e-023       ub1=-1.7556488e-017       lub1=9.2622787e-025
+ wub1=2.8678236e-024       pub1=-1.9050443e-032      uc1=-8.0993047e-010
+ luc1=1.0169165e-016       wuc1=2.3329536e-016       puc1=-2.3885689e-023
+ prt=0                     at=140368.15              lat=-0.014495439
+ wat=-0.0030720205         pat=1.2844711e-009        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     } 
endsection mos
 
// *********************************************************************************************

section mos_3v
// *********************************************************************************************
 

 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V NMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt nch3_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-7 dmci=3.15e-007 xw= + 0 + 
+ dxwn_3v ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg 
+ + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + 
+ (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) 
+ * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_3v 
+ temp1=parn1_3v temp2=parn2_3v fac1=0.401010 * temp1 * sigma + 0.916074 * temp2 
+ * sigma fac2=0.401010 * temp1 * sigma - 0.916074 * temp2 * sigma lef=l * factor 
+ - 0.015e-6 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisn_3v=0.00653247 * geo_fac * fac1 * mismatchflag dlmisn_3v=0.00213862 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisn_3v= - 0.00213862 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisn_3v=0.00213862 * geo_fac * toxn_3v * fac2 * mismatchflag 
nch3_mac ( n1 n2 n3 n4 ) nch3 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nch3 bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln_3v+dlmisn_3v)                     lmax=900.01e-6
+ wmin=1.003e-005-(dxwn_3v+dwmisn_3v)                 wmax=900.01e-6
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.721+(dvthn_3v+vthmisn_3v)
+ k1=0.88                   k2=0.01167+dk2n_3v        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.001
+ voff=-0.1422              nfactor=1                 eta0=0.005
+ etab=-0.0097829           u0=0.04+du0n_3v           ua=-1.081e-009
+ ub=3.345e-018             uc=2.1489e-010            vsat=70000+dvsatn_3v
+ a0=1.35                   ags=0.3105                a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.001               dwg=0                     dwb=0
+ pclm=0.1                  pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.312                kt1l=0                    kt2=-0.0645
+ ute=-1.35                 ua1=2.0192e-009           ub1=-2.185e-018
+ uc1=-7.5e-011             prt=0                     at=150000
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3v         wvth0=0+dwvthn_3v
+ pvth0=0+dpvthn_3v         pvsat=0+dpvsatn_3v        pat=0+dpatn_3v
+ lcit=0+dlcitn_3v          saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.45e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=1.00e-06             pku0=0.00e+00
+ kvth0=4.20e-09            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-5.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.30e-03             lk2we=2.00e-10
+ wk2we=2.00e-10            pcit=0+dpcitn_3v          fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     2: type=n 
+ lmin=1.2e-006-(dxln_3v+dlmisn_3v)                   lmax=1e-005-(dxln_3v+dlmisn_3v)
+ wmin=1.003e-005-(dxwn_3v+dwmisn_3v)                 wmax=900.01e-6
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71865906+(dvthn_3v+vthmisn_3v)
+ lvth0=2.3279393e-008+dlvthn_3v                      k1=0.88
+ k2=0.011899945+dk2n_3v    lk2=-2.2866831e-009       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0010078031
+ lcit=-7.7597977e-011+dlcitn_3v                      voff=-0.14036626
+ lvoff=-1.8235525e-008     nfactor=1                 eta0=0.005
+ etab=-0.0097829           u0=0.04+du0n_3v           ua=-1.078386e-009
+ lua=-2.5995322e-017       ub=3.3816747e-018         lub=-3.6471049e-025
+ uc=2.1767052e-010         luc=-2.7650746e-017       vsat=70000+dvsatn_3v
+ a0=1.3695078              la0=-1.9399494e-007       ags=0.28819604
+ lags=2.2180089e-007       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.0065936222
+ lketa=-7.5514472e-008     dwg=0                     dwb=0
+ pclm=0.10650261           lpclm=-6.4664981e-008     pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.30732202           lkt1=-4.6519988e-008
+ kt1l=0                    kt2=-0.068661673          lkt2=4.1385588e-008
+ ute=-1.3955183            lute=4.5265487e-007       ua1=1.8916447e-009
+ lua1=1.2684683e-015       ub1=-2.1560634e-018       lub1=-2.8775917e-025
+ uc1=-7.7881958e-011       luc1=2.865952e-017        prt=0
+ at=166906.8               lat=-0.16812895           jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3v
+ cjd=cjn_3v                mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3v
+ cjswd=cjswn_3v            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3v
+ cjswgd=cjswgn_3v          mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=3.73e-010
+ jtsswgd=3.73e-010         njtsswg=60                xtsswgs=0.836
+ xtsswgd=0.836             tnjtsswg=3                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ wvth0=0+dwvthn_3v         pvth0=0+dpvthn_3v         saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.45e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=1.00e-06
+ pku0=0.00e+00             kvth0=4.20e-09            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-5.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.30e-03
+ lk2we=2.00e-10            wk2we=2.00e-10            pvsat=0+dpvsatn_3v
+ pat=0+dpatn_3v            pcit=0+dpcitn_3v          fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     3: type=n 
+ lmin=5e-007-(dxln_3v+dlmisn_3v)                     lmax=1.2e-006-(dxln_3v+dlmisn_3v)
+ wmin=1.003e-005-(dxwn_3v+dwmisn_3v)                 wmax=900.01e-6
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.74090483+(dvthn_3v+vthmisn_3v)
+ lvth0=-2.1800001e-009+dlvthn_3v                     k1=0.88
+ k2=0.0015612271+dk2n_3v   lk2=9.5455665e-009        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00085644152
+ lcit=9.5629338e-011+dlcitn_3v                       voff=-0.15553807
+ lvoff=-8.7200004e-010     nfactor=1                 eta0=0.0030951714
+ leta0=2.1800001e-009      etab=-0.0097829           u0=0.034920457+du0n_3v
+ lu0=5.8133336e-009        ua=-1.0932267e-009        lua=-9.0106671e-018
+ ub=2.9125185e-018         lub=1.7222001e-025        uc=1.9098293e-010
+ luc=2.8921335e-018        vsat=70000+dvsatn_3v      a0=1.3904829
+ la0=-2.1800001e-007       ags=0.28008817            lags=2.3108001e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.03677805          lketa=-2.5877328e-008
+ dwg=0                     dwb=0                     pclm=0.018252857
+ lpclm=3.6333335e-008      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.32635655           lkt1=-2.4735735e-008      kt1l=0
+ kt2=-0.0213885            lkt2=-1.2716667e-008      ute=-1
+ ua1=3.3028043e-009        lua1=-3.4654735e-016      ub1=-3.0018065e-018
+ lub1=6.8016003e-025       uc1=-9.3144268e-011       luc1=4.6126622e-017
+ prt=0                     at=29524.143              lat=-0.010900001
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     wvth0=0+dwvthn_3v         pvth0=0+dpvthn_3v
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ pvsat=0+dpvsatn_3v        pat=0+dpatn_3v            pcit=0+dpcitn_3v
+ fnoimod=1                 noia=noian_3v             noib=noibn_3v
+ noic=noicn_3v             em=3.00e7                 ef=0.951
+ minr=1e-3
 
 
 
     4: type=n 
+ lmin=3.5e-007             lmax=5e-007-(dxln_3v+dlmisn_3v)
+ wmin=1.003e-005-(dxwn_3v+dwmisn_3v)                 wmax=900.01e-6
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.706554+(dvthn_3v+vthmisn_3v)
+ lvth0=1.3087569e-008+dlvthn_3v                      k1=0.88
+ k2=-0.0008368168+dk2n_3v  lk2=1.0611401e-008        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0013809793
+ lcit=-1.3750673e-010+dlcitn_3v                      voff=-0.15494801
+ lvoff=-1.134256e-009      nfactor=1                 eta0=0.0040738667
+ leta0=1.7450092e-009      etab=0.046969554          letab=-2.5224196e-008
+ u0=0.0303324+du0n_3v      lu0=7.8525415e-009        ua=-1.6546979e-009
+ lua=2.405408e-016         ub=3.3490767e-018         lub=-2.1812615e-026
+ uc=3.3164598e-010         luc=-5.9626965e-017       vsat=70000+dvsatn_3v
+ a0=0.74295467             la0=6.9800369e-008        ags=2.1937773
+ lags=-6.1947827e-007      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.21010638
+ lketa=5.116018e-008       dwg=0                     dwb=0
+ pclm=-1.0974707           lpclm=5.3222781e-007      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.34194381           lkt1=-1.7807819e-008
+ kt1l=0                    kt2=-0.05                 ute=-1
+ ua1=4.6718028e-010        lua1=9.1377408e-016       ub1=6.9945543e-019
+ lub1=-9.6490285e-025      uc1=5.79685e-011          luc1=-2.1036959e-017
+ prt=0                     at=12852.267              lat=-0.0034900184
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     wvth0=0+dwvthn_3v         pvth0=0+dpvthn_3v
+ pvsat=0+dpvsatn_3v        pat=0+dpatn_3v            saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.45e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=1.00e-06
+ pku0=0.00e+00             kvth0=4.20e-09            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-5.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.30e-03
+ lk2we=2.00e-10            wk2we=2.00e-10            pcit=0+dpcitn_3v
+ fnoimod=1                 noia=noian_3v             noib=noibn_3v
+ noic=noicn_3v             em=3.00e7                 ef=0.951
+ minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-(dxln_3v+dlmisn_3v)                     lmax=900.01e-6
+ wmin=1.23e-006-(dxwn_3v+dwmisn_3v)                  wmax=1.003e-005-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71965591+(dvthn_3v+vthmisn_3v)
+ wvth0=1.3417791e-008+dwvthn_3v                      k1=0.88
+ k2=0.011787608+dk2n_3v    wk2=-1.1740567e-009       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0010273523
+ wcit=-2.7305204e-010      voff=-0.14091236          wvoff=-1.2854244e-008
+ nfactor=1                 eta0=0.005                etab=-0.0097829
+ u0=0.04+du0n_3v           ua=-1.1259719e-009        wua=4.4894586e-016
+ ub=3.4175809e-018         wub=-7.245607e-025        uc=2.2063599e-010
+ wuc=-5.7361055e-017       vsat=70000+dvsatn_3v      a0=1.3634409
+ wa0=-1.3417791e-007       ags=0.31334947            wags=-2.8445716e-008
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=0.000759415          wketa=-1.7563888e-008
+ dwg=0                     dwb=0                     pclm=0.046236364
+ wpclm=5.3671163e-007      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.31356452           wkt1=1.5618308e-008       kt1l=0
+ kt2=-0.066448932          wkt2=1.9455797e-008       ute=-1.3701614
+ wute=2.0126686e-007       ua1=1.854401e-009         wua1=1.6451553e-015
+ ub1=-1.9980235e-018       wub1=-1.8665489e-024      uc1=-7.7978506e-011
+ wuc1=2.9733824e-017       prt=0                     at=150000
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3v         pvth0=0+dpvthn_3v
+ pvsat=0+dpvsatn_3v        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.45e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=1.00e-06             pku0=0.00e+00
+ kvth0=4.20e-09            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-5.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.30e-03             lk2we=2.00e-10
+ wk2we=2.00e-10            pat=0+dpatn_3v            lcit=0+dlcitn_3v
+ pcit=0+dpcitn_3v          fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
 
     6: type=n 
+ lmin=1.2e-006-(dxln_3v+dlmisn_3v)                   lmax=1e-005-(dxln_3v+dlmisn_3v)
+ wmin=1.23e-006-(dxwn_3v+dwmisn_3v)                  wmax=1.003e-005-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71713143+(dvthn_3v+vthmisn_3v)
+ lvth0=2.5104621e-008+dlvthn_3v                      wvth0=1.5250056e-008+dwvthn_3v
+ pvth0=-1.8220885e-014+dpvthn_3v                     k1=0.88
+ k2=0.012025421+dk2n_3v    lk2=-2.3649245e-009       wk2=-1.2525998e-009
+ pk2=7.810686e-016         k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0010397614          lcit=-1.2340251e-010+dlcitn_3v
+ wcit=-3.1903317e-010      pcit=4.5725745e-016+dpcitn_3v
+ voff=-0.13919434          lvoff=-1.7084762e-008     wvoff=-1.1699044e-008
+ pvoff=-1.1487834e-014     nfactor=1                 eta0=0.005
+ etab=-0.0097829           u0=0.04001748+du0n_3v     lu0=-1.7383123e-010
+ wu0=-1.7450142e-010       pu0=1.7353224e-015        ua=-1.1251538e-009
+ lua=-8.1359022e-018       wua=4.6687414e-016        pua=-1.7828702e-022
+ ub=3.4582586e-018         lub=-4.0451785e-025       wub=-7.6452152e-025
+ pub=3.9738882e-031        uc=2.2380876e-010         luc=-3.1551519e-017
+ wuc=-6.1276867e-017       puc=3.8940634e-023        vsat=70000+dvsatn_3v
+ a0=1.3812007              la0=-1.7661182e-007       wa0=-1.1672777e-007
+ pa0=-1.7353224e-013       ags=0.29150349            lags=2.1724651e-007
+ wags=-3.3017654e-008      pags=4.5465446e-014       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=0.0087730341         lketa=-7.9691115e-008     wketa=-2.1756634e-008
+ pketa=4.1694591e-014      dwg=0                     dwb=0
+ pclm=0.047494915          lpclm=-1.2515613e-008     wpclm=5.8906205e-007
+ ppclm=-5.2059671e-013     pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.30902236           lkt1=-4.5169319e-008      wkt1=1.6974184e-008
+ pkt1=-1.3483455e-014      kt1l=0                    kt2=-0.071169971
+ lkt2=4.6948187e-008       wkt2=2.5039842e-008       pkt2=-5.5530316e-014
+ ute=-1.4244198            lute=5.3957048e-007       wute=2.8851757e-007
+ pute=-8.6766119e-013      ua1=1.6893979e-009        lua1=1.6408669e-015
+ wua1=2.0189897e-015       pua1=-3.7175811e-021      ub1=-1.9480687e-018
+ lub1=-4.9677383e-025      wub1=-2.0763694e-024      pub1=2.0865516e-030
+ uc1=-8.1247825e-011       luc1=3.251162e-017        wuc1=3.3600776e-017
+ puc1=-3.8454744e-023      prt=0                     at=167256.4
+ lat=-0.17160558           wat=-0.0034900284         pat=3.4706447e-008+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     7: type=n 
+ lmin=5e-007-(dxln_3v+dlmisn_3v)                     lmax=1.2e-006-(dxln_3v+dlmisn_3v)
+ wmin=1.23e-006-(dxwn_3v+dwmisn_3v)                  wmax=1.003e-005-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.74075868+(dvthn_3v+vthmisn_3v)
+ lvth0=-1.9358236e-009+dlvthn_3v                     wvth0=1.4589931e-009+dwvthn_3v
+ pvth0=-2.4375654e-015+dpvthn_3v                     k1=0.88
+ k2=0.0025645168+dk2n_3v   lk2=8.4627022e-009        wk2=-1.001564e-008
+ pk2=1.0810018e-014        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00083799938         lcit=1.0750608e-010+dlcitn_3v
+ wcit=1.8410423e-010       pcit=-1.1856318e-016+dpcitn_3v
+ voff=-0.15324116          lvoff=-1.0087389e-009     wvoff=-2.2929555e-008
+ pvoff=1.3650366e-015      nfactor=1                 eta0=0.0028391452
+ leta0=2.4730119e-009      weta0=2.5558591e-009      peta0=-2.9250785e-015
+ etab=-0.0087773227        letab=-1.150843e-009      wetab=-1.0038478e-008
+ petab=1.1488636e-014      u0=0.034700706+du0n_3v    lu0=5.9110042e-009
+ wu0=2.1937321e-009        pu0=-9.7502617e-016       ua=-1.1107748e-009
+ lua=-2.459206e-017        wua=1.7517941e-016        pua=1.5554593e-022
+ ub=2.9202683e-018         lub=2.1119058e-025        wub=-7.7364029e-026
+ pub=-3.8903544e-031       uc=1.9345248e-010         luc=3.1900288e-018
+ wuc=-2.4653076e-017       puc=-2.9738298e-024       vsat=70000+dvsatn_3v
+ a0=1.4079771              la0=-2.0725624e-007       wa0=-1.7464098e-007
+ pa0=-1.0725288e-013       ags=0.30988325            lags=1.962116e-007
+ wags=-2.9743834e-007      pags=3.4808434e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.039181469         lketa=-2.4809105e-008     wketa=2.3992848e-008
+ pketa=-1.0663861e-014     dwg=0                     dwb=0
+ pclm=-0.0045756821        lpclm=4.7077102e-008      wpclm=2.2789274e-007
+ ppclm=-1.0725288e-013     pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.32670944           lkt1=-2.4927169e-008      wkt1=3.5228571e-009
+ pkt1=1.9110513e-015       kt1l=0                    kt2=-0.017542854
+ lkt2=-1.4425903e-008      wkt2=-3.8390312e-008      pkt2=1.7062958e-014
+ ute=-0.9635307            lute=1.2101389e-008       wute=-3.6406569e-007
+ pute=-1.2080574e-013      ua1=3.4010641e-009        lua1=-3.180666e-016
+ wua1=-9.8090848e-016      pua1=-2.8431763e-022      ub1=-2.9040905e-018
+ lub1=5.9735489e-025       wub1=-9.754795e-025       pub1=8.2662719e-031
+ uc1=-9.8561528e-011       luc1=5.232646e-017        wuc1=5.4079423e-017
+ puc1=-6.1891736e-023      prt=0                     at=25129.119
+ lat=-0.0089465883         wat=0.043874642           pat=-1.9500524e-008+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     8: type=n 
+ lmin=3.5e-007             lmax=5e-007-(dxln_3v+dlmisn_3v)
+ wmin=1.23e-006-(dxwn_3v+dwmisn_3v)                  wmax=1.003e-005-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71078311+(dvthn_3v+vthmisn_3v)
+ lvth0=1.1387117e-008+dlvthn_3v                      wvth0=-4.2218363e-008+dwvthn_3v
+ pvth0=1.6975272e-014+dpvthn_3v                      k1=0.88
+ k2=-0.0013363711+dk2n_3v  lk2=1.0196491e-008        wk2=4.9869502e-009
+ pk2=4.1419664e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0014308423          lcit=-1.5598888e-010+dlcitn_3v
+ wcit=-4.9777227e-010      pcit=1.8450365e-016+dpcitn_3v
+ voff=-0.15167115          lvoff=-1.7065461e-009     wvoff=-3.2712259e-008
+ pvoff=5.7130571e-015      nfactor=1                 eta0=0.005268656
+ leta0=1.3931916e-009      weta0=-1.1927343e-008     peta0=3.5121253e-015
+ etab=0.046977682          letab=-2.5931713e-008     wetab=-8.1147453e-011
+ petab=7.063001e-015       u0=0.029804692+du0n_3v    lu0=8.0870866e-009
+ wu0=5.2680035e-009        pu0=-2.3414169e-015       ua=-1.8669266e-009
+ lua=3.1148717e-016        wua=2.1186376e-015        pua=-7.0824348e-022
+ ub=3.614693e-018          lub=-9.7453411e-026       wub=-2.6515943e-024
+ pub=7.5510694e-031        uc=3.3997314e-010         luc=-6.1932544e-017
+ wuc=-8.3128434e-017       puc=2.3016128e-023        vsat=70000+dvsatn_3v
+ a0=0.92446411             la0=7.6459165e-009        wa0=-1.8119725e-006
+ pa0=6.2047547e-013        ags=2.3068638             lags=-6.9136635e-007
+ wags=-1.1289191e-006      pags=7.1764427e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.22557772          lketa=5.8036574e-008      wketa=1.5444733e-007
+ pketa=-6.8645659e-014     dwg=0                     dwb=0
+ pclm=-1.1488974           lpclm=5.5568232e-007      wpclm=5.1338256e-007
+ ppclm=-2.3414169e-013     pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.35195967           lkt1=-1.3704453e-008      wkt1=9.9986294e-008
+ pkt1=-4.0963088e-014      kt1l=0                    kt2=-0.045514482
+ lkt2=-1.9936334e-009      wkt2=-4.477803e-008       pkt2=1.9902043e-014
+ ute=-0.96408736           lute=1.23488e-008         wute=-3.5850872e-007
+ pute=-1.232756e-013       ua1=3.8957075e-010        lua1=1.0204217e-015
+ wua1=7.7476045e-016       pua1=-1.0646422e-021      ub1=7.86171e-019
+ lub1=-1.0428187e-024      wub1=-8.6566419e-025      pub1=7.7781868e-031
+ uc1=9.1335381e-011        luc1=-3.207512e-017       wuc1=-3.3309489e-016
+ puc1=1.1019176e-022       prt=0                     at=15226.953
+ lat=-0.0045454714         wat=-0.023706016          pat=1.0536376e-008+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-(dxln_3v+dlmisn_3v)                     lmax=900.01e-6
+ wmin=5.3e-007-(dxwn_3v+dwmisn_3v)                   wmax=1.23e-006-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.73272429+(dvthn_3v+vthmisn_3v)
+ wvth0=-2.0394851e-009+dwvthn_3v                     k1=0.88
+ k2=0.013438813+dk2n_3v    wk2=-3.1271018e-009       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000794086
+ wcit=2.8552792e-012       voff=-0.15093855          wvoff=-9.9526875e-010
+ nfactor=1                 eta0=0.005                etab=-0.0097829
+ u0=0.04+du0n_3v           ua=-6.6254764e-010        wua=-9.9192399e-017
+ ub=2.7891366e-018         wub=1.8763263e-026        uc=1.7729906e-010
+ wuc=-6.1021396e-018       vsat=70000+dvsatn_3v      a0=1.1465429
+ wa0=1.2236911e-007        ags=0.28192006            wags=8.7289964e-009
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.010415202         wketa=-4.3465507e-009
+ dwg=0                     dwb=0                     pclm=0.72760571
+ wpclm=-2.6921204e-007     pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.306395             wkt1=7.138198e-009        kt1l=0
+ kt2=-0.05                 ute=-1.1199931            wute=-9.4632111e-008
+ ua1=3.8423167e-009        wua1=-7.0615134e-016      ub1=-4.0078611e-018
+ wub1=5.1068708e-025       uc1=-5.284e-011           prt=0
+ at=150000                 jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3v                cjd=cjn_3v
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3v            cjswd=cjswn_3v
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3v          cjswgd=cjswgn_3v
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=3.73e-010         jtsswgd=3.73e-010
+ njtsswg=60                xtsswgs=0.836             xtsswgd=0.836
+ tnjtsswg=3                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     lvth0=0+dlvthn_3v
+ pvth0=0+dpvthn_3v         pvsat=0+dpvsatn_3v        pat=0+dpatn_3v
+ lcit=0+dlcitn_3v          saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.45e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=1.00e-06             pku0=0.00e+00
+ kvth0=4.20e-09            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-5.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.30e-03             lk2we=2.00e-10
+ wk2we=2.00e-10            pcit=0+dpcitn_3v          fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     10: type=n 
+ lmin=1.2e-006-(dxln_3v+dlmisn_3v)                   lmax=1e-005-(dxln_3v+dlmisn_3v)
+ wmin=5.3e-007-(dxwn_3v+dwmisn_3v)                   wmax=1.23e-006-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.73035856+(dvthn_3v+vthmisn_3v)
+ lvth0=2.3525859e-008+dlvthn_3v                      wvth0=-3.9499914e-010+dwvthn_3v
+ pvth0=-1.6353525e-014+dpvthn_3v                     k1=0.88
+ k2=0.012450657+dk2n_3v    lk2=9.8266761e-009        wk2=-1.7555686e-009
+ pk2=-1.3639157e-014       k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00074936663         lcit=4.4470994e-010+dlcitn_3v
+ wcit=2.4445789e-011       pcit=-2.1470596e-016+dpcitn_3v
+ voff=-0.14756933          lvoff=-3.3505063e-008     wvoff=-1.7931097e-009
+ pvoff=7.9340974e-015      nfactor=1                 eta0=0.0054484946
+ leta0=-4.4600361e-009     weta0=-5.3047936e-010     peta0=5.2753307e-015
+ etab=-0.0091106336        letab=-6.6853266e-009     wetab=-7.9515673e-010
+ petab=7.9074043e-015      u0=0.039869948+du0n_3v    lu0=1.2932996e-009
+ ua=-6.3754024e-010        lua=-2.4868513e-016       wua=-1.0987519e-016
+ pua=1.0623461e-022        ub=2.7834715e-018         lub=5.6336132e-026
+ wub=3.3616685e-026        pub=-1.4770926e-031       uc=1.7482096e-010
+ luc=2.4643366e-017        wuc=-3.3340983e-018       puc=-2.7526676e-023
+ vsat=70000+dvsatn_3v      a0=1.1656011              la0=-1.8952382e-007
+ wa0=1.3828349e-007        pa0=-1.5825992e-013       ags=0.25847811
+ lags=2.3311755e-007       wags=6.0447709e-009       pags=2.6693174e-014
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.0055340002        lketa=-4.8540919e-008
+ wketa=-4.8342735e-009     pketa=4.8501391e-015      dwg=0
+ dwb=0                     pclm=0.80003368           lpclm=-7.2025704e-007
+ wpclm=-3.010408e-007      ppclm=3.1651984e-013      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.30070651           lkt1=-5.6568926e-008
+ wkt1=7.138198e-009        pkt1=1.2744816e-028       kt1l=0
+ kt2=-0.049237559          lkt2=-7.5820614e-009      wkt2=-9.0181491e-010
+ pkt2=8.9680623e-015       ute=-1.0766254            lute=-4.3126887e-007
+ wute=-1.2285361e-007      pute=2.806476e-013        ua1=4.0887044e-009
+ lua1=-2.4501928e-015      wua1=-8.1891003e-016      pua1=1.1213243e-021
+ ub1=-4.1866968e-018       lub1=1.7784244e-024       wub1=5.7148001e-025
+ pub1=-6.045529e-031       uc1=-5.284e-011           prt=0
+ at=164216.05              lat=-0.14137095           wat=0.00010609587
+ pat=-1.0550662e-009+dpatn_3v                        jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3v
+ cjd=cjn_3v                mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3v
+ cjswd=cjswn_3v            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3v
+ cjswgd=cjswgn_3v          mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=3.73e-010
+ jtsswgd=3.73e-010         njtsswg=60                xtsswgs=0.836
+ xtsswgd=0.836             tnjtsswg=3                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.45e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=1.00e-06
+ pku0=0.00e+00             kvth0=4.20e-09            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-5.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.30e-03
+ lk2we=2.00e-10            wk2we=2.00e-10            xgl=0
+ pvsat=0+dpvsatn_3v        fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
 
     11: type=n 
+ lmin=5e-007-(dxln_3v+dlmisn_3v)                     lmax=1.2e-006-(dxln_3v+dlmisn_3v)
+ wmin=5.3e-007-(dxwn_3v+dwmisn_3v)                   wmax=1.23e-006-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.75747255+(dvthn_3v+vthmisn_3v)
+ lvth0=-7.5050137e-009+dlvthn_3v                     wvth0=-1.8310171e-008+dwvthn_3v
+ pvth0=4.1496726e-015+dpvthn_3v                      k1=0.88
+ k2=0.009931143+dk2n_3v    lk2=1.2710159e-008        wk2=-1.8728886e-008
+ pk2=5.7861257e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0011272141          lcit=1.2278591e-011+dlcitn_3v
+ wcit=-1.5797899e-010      pcit=-5.9281038e-018+dpcitn_3v
+ voff=-0.17981873          lvoff=3.403084e-009       wvoff=8.5063895e-009
+ pvoff=-3.8532675e-015     nfactor=1                 eta0=-0.00063821722
+ leta0=2.505962e-009       weta0=6.6688833e-009      peta0=-2.9640519e-015
+ etab=-0.029055015         letab=1.614022e-008       wetab=1.3945977e-008
+ petab=-8.9632336e-015     u0=0.034803683+du0n_3v    lu0=7.0914365e-009
+ wu0=2.0719304e-009        pu0=-2.3712415e-015       ua=-1.0180513e-009
+ lua=1.8679452e-016        wua=6.5505973e-017        pua=-9.4482118e-023
+ ub=2.8751231e-018         lub=-4.8555454e-026       wub=-2.3966305e-026
+ pub=-8.1807832e-032       uc=1.8668932e-010         luc=1.1060507e-017
+ wuc=-1.6653607e-017       puc=-1.2283031e-023       vsat=70000+dvsatn_3v
+ a0=1.17712                la0=-2.0270679e-007       wa0=9.8416696e-008
+ pa0=-1.1263397e-013       ags=0.33225154            lags=1.486868e-007
+ wags=-3.2389555e-007      pags=4.0429668e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.018072373         lketa=-3.4191253e-008     wketa=-9.7499074e-010
+ pketa=4.3334439e-016      dwg=0                     dwb=0
+ pclm=0.23944304           lpclm=-7.8683471e-008     wpclm=-6.0732604e-008
+ ppclm=4.1496726e-014      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.33359791           lkt1=-1.8926034e-008      wkt1=1.1670546e-008
+ pkt1=-5.1870908e-015      kt1l=0                    kt2=-0.056081536
+ lkt2=2.505962e-010        wkt2=7.1932408e-009       pkt2=-2.9640519e-016
+ ute=-1.3713281            lute=-9.3993424e-008      wute=1.1827705e-007
+ pute=4.683202e-015        ua1=2.6434079e-009        lua1=-7.961088e-016
+ wua1=-8.4752765e-017      pua1=2.8111068e-022       ub1=-4.2603573e-018
+ lub1=1.8627258e-024       wub1=6.2871283e-025       pub1=-6.7005357e-031
+ uc1=-4.2195694e-011       luc1=-1.2181983e-017      wuc1=-1.2590085e-017
+ puc1=1.4408849e-023       prt=0                     at=65540.289
+ lat=-0.028440489          wat=-0.0039236897         pat=3.5568623e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     12: type=n 
+ lmin=3.5e-007             lmax=5e-007-(dxln_3v+dlmisn_3v)
+ wmin=5.3e-007-(dxwn_3v+dwmisn_3v)                   wmax=1.23e-006-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.7036627+(dvthn_3v+vthmisn_3v)
+ lvth0=1.6411313e-008+dlvthn_3v                      wvth0=-3.3796336e-008+dwvthn_3v
+ pvth0=1.1032653e-014+dpvthn_3v                      k1=0.88
+ k2=0.015290002+dk2n_3v    lk2=1.0328361e-008        wk2=-1.4678724e-008
+ pk2=3.9859908e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0013173146          lcit=-7.2213467e-011+dlcitn_3v
+ wcit=-3.6349173e-010      pcit=8.5414089e-017+dpcitn_3v
+ voff=-0.19216073          lvoff=8.8886083e-009      wvoff=1.517881e-008
+ pvoff=-6.8188915e-015     nfactor=1                 eta0=-0.0048153333
+ leta0=4.3625231e-009      etab=0.060957079          letab=-2.3866555e-008
+ wetab=-1.6615978e-008     petab=4.6203328e-015      u0=0.038371346+du0n_3v
+ lu0=5.5057534e-009        wu0=-4.8646344e-009       pu0=7.1178408e-016
+ ua=6.9218223e-010         lua=-5.7333586e-016       wua=-9.0827643e-016
+ pua=3.3832521e-022        ub=5.4007924e-019         lub=9.8927814e-025
+ wub=9.8505882e-025        pub=-5.3027914e-031       uc=3.1609715e-010
+ luc=-4.6456097e-017       wuc=-5.4887909e-017       puc=4.710587e-024
+ vsat=70000+dvsatn_3v      a0=-0.93676969            la0=7.3683264e-007
+ wa0=3.8949489e-007        pa0=-2.4200659e-013       ags=1.448881
+ lags=-3.4761032e-007      wags=-1.1409707e-007      pags=3.1104964e-013
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.095               dwg=0
+ dwb=0                     pclm=-0.85076232          lpclm=4.058692e-007
+ wpclm=1.6074841e-007      ppclm=-5.6942726e-014     pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.09926488           lkt1=-1.2307769e-007
+ wkt1=-1.989011e-007       pkt1=8.8403582e-014       kt1l=0
+ kt2=-0.090243803          lkt2=1.5434357e-008       wkt2=8.1278106e-009
+ pkt2=-7.1178408e-016      ute=-0.94106918           lute=-2.8522629e-007
+ wute=-3.8573461e-007      pute=2.2869622e-013       ua1=-3.8980847e-010
+ lua1=5.5203457e-016       wua1=1.6966102e-015       pua1=-5.106339e-022
+ ub1=3.284119e-018         lub1=-1.4904921e-024      wub1=-3.8202371e-024
+ pub1=1.3073267e-030       uc1=-2.6240382e-010       luc1=8.5691719e-017
+ wuc1=8.5307829e-017       puc1=-2.9102858e-023      prt=0
+ at=-10971.815             lat=0.0055660808          wat=0.0072818865
+ pat=-1.4235682e-009+dpatn_3v                        jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3v
+ cjd=cjn_3v                mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3v
+ cjswd=cjswn_3v            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3v
+ cjswgd=cjswgn_3v          mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=3.73e-010
+ jtsswgd=3.73e-010         njtsswg=60                xtsswgs=0.836
+ xtsswgd=0.836             tnjtsswg=3                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.45e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=1.00e-06
+ pku0=0.00e+00             kvth0=4.20e-09            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-5.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.30e-03
+ lk2we=2.00e-10            wk2we=2.00e-10            xgl=0
+ pvsat=0+dpvsatn_3v        fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-(dxln_3v+dlmisn_3v)                     lmax=900.01e-6
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.72989355+(dvthn_3v+vthmisn_3v)
+ wvth0=-6.7280516e-010+dwvthn_3v                     k1=0.88
+ k2=0.02316141+dk2n_3v     wk2=-7.8211716e-009       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00095734276
+ wcit=-7.5965085e-011      voff=-0.153               nfactor=1
+ eta0=0.005                etab=-0.0097829           u0=0.039442581+du0n_3v
+ wu0=2.6912207e-010        ua=-8.8305032e-010        wua=7.2662957e-018
+ ub=2.9567639e-018         wub=-6.2167197e-026       uc=1.8180065e-010
+ wuc=-8.2755035e-018       vsat=70000+dvsatn_3v      a0=1.3163871
+ wa0=4.036831e-008         ags=0.29453729            wags=2.6373962e-009
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.02968455          wketa=4.9566902e-009
+ dwg=0                     dwb=0                     pclm=0.11983226
+ wpclm=2.4220986e-008      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.30136484           wkt1=4.7096361e-009       kt1l=0
+ kt2=-0.058082581          wkt2=3.9022699e-009       ute=-1.4364026
+ wute=5.8130366e-008       ua1=2.3400117e-009        wua1=1.9161491e-017
+ ub1=-2.9507132e-018       wub1=2.9603427e-028       uc1=-5.284e-011
+ prt=0                     at=150000                 jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3v
+ cjd=cjn_3v                mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3v
+ cjswd=cjswn_3v            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3v
+ cjswgd=cjswgn_3v          mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=3.73e-010
+ jtsswgd=3.73e-010         njtsswg=60                xtsswgs=0.836
+ xtsswgd=0.836             tnjtsswg=3                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3v         pvth0=0+dpvthn_3v         pvsat=0+dpvsatn_3v
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ pat=0+dpatn_3v            lcit=0+dlcitn_3v          pcit=0+dpcitn_3v
+ fnoimod=1                 noia=noian_3v             noib=noibn_3v
+ noic=noicn_3v             em=3.00e7                 ef=0.951
+ minr=1e-3
 
 
     14: type=n 
+ lmin=1.2e-006-(dxln_3v+dlmisn_3v)                   lmax=1e-005-(dxln_3v+dlmisn_3v)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.72933911+(dvthn_3v+vthmisn_3v)
+ lvth0=5.5136283e-009+dlvthn_3v                      wvth0=9.7193434e-011+dwvthn_3v
+ pvth0=-7.6572202e-015+dpvthn_3v                     k1=0.88
+ k2=0.025593652+dk2n_3v    lk2=-2.4187335e-008       wk2=-8.1010066e-009
+ pk2=2.7828079e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00095734276         wcit=-7.5965085e-011
+ voff=-0.15161678          lvoff=-1.3755368e-008     wvoff=1.6099971e-010
+ pvoff=-1.6010551e-015     nfactor=1                 eta0=0.0039872704
+ leta0=1.0071049e-008      weta0=1.7499968e-010      peta0=-1.7402773e-015
+ etab=-0.010772957         letab=9.8455815e-009      wetab=7.4129865e-012
+ petab=-7.3718148e-017     u0=0.039385022+du0n_3v    lu0=5.7238938e-010
+ wu0=2.3412213e-010        pu0=3.4805547e-016        ua=-8.9504174e-010
+ lua=1.1924815e-016        wua=1.4446533e-017        pua=-7.1403579e-023
+ ub=2.9883159e-018         lub=-3.1376784e-025       wub=-6.5282191e-026
+ pub=3.0976936e-032        uc=1.8507905e-010         luc=-3.2601981e-017
+ wuc=-8.2867035e-018       puc=1.1137775e-025        vsat=70000+dvsatn_3v
+ a0=1.3720327              la0=-5.5336536e-007       wa0=3.8618313e-008
+ pa0=1.7402773e-014        ags=0.27192957            lags=2.2482153e-007
+ wags=-4.4959814e-010      pags=3.0698492e-014       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.028957231         lketa=-7.2327907e-009     wketa=6.4744624e-009
+ pketa=-1.5093425e-014     dwg=0                     dwb=0
+ pclm=0.12705981           lpclm=-7.1874084e-008     wpclm=2.3870986e-008
+ ppclm=3.4805547e-015      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.29567635           lkt1=-5.6568926e-008      wkt1=4.7096361e-009
+ pkt1=5.0435742e-030       kt1l=0                    kt2=-0.060311677
+ lkt2=2.2167156e-008       wkt2=4.444769e-009        pkt2=-5.3948597e-015
+ ute=-1.4598979            lute=2.3364834e-007       wute=6.2190359e-008
+ pute=-4.0374434e-014      ua1=2.3450186e-009        lua1=-4.9790367e-017
+ wua1=2.2941484e-017       pua1=-3.758999e-023       ub1=-2.9985859e-018
+ lub1=4.7606826e-025       wub1=-2.1399613e-027      pub1=2.422466e-032
+ uc1=-5.284e-011           prt=0                     at=164725.78
+ lat=-0.1464399            wat=-0.00013999975        pat=1.3922219e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     pvsat=0+dpvsatn_3v        lcit=0+dlcitn_3v
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ pcit=0+dpcitn_3v          fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
     15: type=n 
+ lmin=5e-007-(dxln_3v+dlmisn_3v)                     lmax=1.2e-006-(dxln_3v+dlmisn_3v)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.72506398+(dvthn_3v+vthmisn_3v)
+ lvth0=1.0406336e-008+dlvthn_3v                      wvth0=-2.6633165e-009+dwvthn_3v
+ pvth0=-4.497927e-015+dpvthn_3v                      k1=0.88
+ k2=-0.02374288+dk2n_3v    lk2=3.2276353e-008        wk2=-2.4710672e-009
+ pk2=-3.6604325e-015       k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00098646054         lcit=-3.3324129e-011+dlcitn_3v
+ wcit=-9.0023147e-011      pcit=1.6088889e-017+dpcitn_3v
+ voff=-0.15889248          lvoff=-5.4286222e-009     wvoff=-1.5968035e-009
+ pvoff=4.1068029e-016      nfactor=1                 eta0=0.017731458
+ leta0=-5.6586239e-009     weta0=-2.199996e-009      peta0=9.7781022e-016
+ etab=0.0037841991         letab=-6.8145013e-009     wetab=-1.9087955e-009
+ petab=2.1193059e-015      u0=0.037272474+du0n_3v    lu0=2.9901163e-009
+ wu0=8.7999839e-010        pu0=-3.9112409e-016       ua=-9.6231526e-010
+ lua=1.9624e-016           wua=3.8596628e-017        pua=-9.9042397e-023
+ ub=3.0345285e-018         lub=-3.6665633e-025       wub=-1.0092724e-025
+ pub=7.177127e-032         uc=1.595033e-010          luc=-3.3315596e-018
+ wuc=-3.528198e-018        puc=-5.3345414e-024       vsat=70000+dvsatn_3v
+ a0=1.2694818              la0=-4.3600002e-007       wa0=5.3824413e-008
+ pa0=1.2737982e-028        ags=-0.12001103           lags=6.7338187e-007
+ wags=-1.0554318e-007      pags=1.509739e-013        a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=0.0026435952         lketa=-4.3398672e-008     wketa=-1.097666e-008
+ pketa=4.8786863e-015      dwg=0                     dwb=0
+ pclm=0.089762285          lpclm=-2.9188561e-008     wpclm=1.1533265e-008
+ ppclm=1.7600584e-014      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.32165763           lkt1=-2.6834395e-008      wkt1=5.9057761e-009
+ pkt1=-1.3689343e-015      kt1l=0                    kt2=-0.043102615
+ lkt2=2.4720732e-009       wkt2=9.2701786e-010       pkt2=-1.3689343e-015
+ ute=-1.1764257            lute=-9.0774267e-008      wute=2.4178172e-008
+ pute=3.1289927e-015       ua1=2.4321373e-009        lua1=-1.4949428e-016
+ wua1=1.7248684e-017       pua1=-3.1074809e-023      ub1=-2.8588044e-018
+ lub1=3.1609392e-025       wub1=-4.7956906e-026      pub1=7.6660321e-032
+ uc1=-5.7531871e-011       luc1=5.3696581e-018       wuc1=-5.1857792e-018
+ puc1=5.9349169e-024       prt=0                     at=58015.101
+ lat=-0.024313799          wat=-0.0002905288         pat=1.5644964e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     16: type=n 
+ lmin=3.5e-007             lmax=5e-007-(dxln_3v+dlmisn_3v)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_3v+dwmisn_3v)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3v+toxmisn_3v)
+ toxm=6.7e-009             dtox=5.58e-010            epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3v+dlmisn_3v)                    xw=0+(dxwn_3v+dwmisn_3v)
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.67162906+(dvthn_3v+vthmisn_3v)
+ lvth0=3.4156022e-008+dlvthn_3v                      wvth0=-1.8330496e-008+dwvthn_3v
+ pvth0=2.4655075e-015+dpvthn_3v                      k1=0.88
+ k2=0.023240464+dk2n_3v    lk2=1.1394136e-008        wk2=-1.8517207e-008
+ pk2=3.4714346e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00035827659         lcit=2.4587851e-010+dlcitn_3v
+ wcit=9.9531833e-011       pcit=-6.8160717e-017+dpcitn_3v
+ voff=-0.16636409          lvoff=-2.107791e-009      wvoff=2.7241931e-009
+ pvoff=-1.5098299e-015     nfactor=1                 eta0=-0.012475093
+ leta0=7.7669798e-009      weta0=3.6981319e-009      peta0=-1.6436717e-015
+ etab=0.009483205          letab=-9.3474814e-009     wetab=8.2356086e-009
+ petab=-2.389476e-015      u0=0.029389718+du0n_3v    lu0=6.4936859e-009
+ wu0=-5.2830455e-010       pu0=2.3481024e-016        ua=-7.8454146e-010
+ lua=1.1722666e-016        wua=-1.9531423e-016       pua=4.9216227e-024
+ ub=2.0730703e-018         lub=6.0673408e-026        wub=2.4493075e-025
+ pub=-8.1948775e-032       uc=2.1892042e-010         luc=-2.9740093e-017
+ wuc=-7.9709862e-018       puc=-3.3598998e-024       vsat=70000+dvsatn_3v
+ a0=0.66671675             la0=-1.6809505e-007       wa0=-3.8466837e-007
+ pa0=1.948925e-013         ags=0.45403966            lags=4.1823931e-007
+ wags=3.6621234e-007       pags=-5.8702561e-014      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.095               dwg=0                     dwb=0
+ pclm=-0.2407337           lpclm=1.1770369e-007      wpclm=-1.337734e-007
+ ppclm=8.2183585e-014      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.56416658           lkt1=8.0951135e-008       wkt1=2.5553444e-008
+ pkt1=-1.0101537e-014      kt1l=0                    kt2=-0.086457734
+ lkt2=2.1741689e-008       wkt2=6.2998964e-009       pkt2=-3.7569639e-015
+ ute=-2.1679745            lute=3.4992951e-007       wute=2.0661527e-007
+ pute=-7.7957e-014         ua1=3.6436189e-009        lua1=-6.879494e-016
+ wua1=-2.5072857e-016      pua1=8.803036e-023        ub1=-5.7556437e-018
+ lub1=1.6036231e-024       wub1=5.4416037e-025       pub1=-1.8651212e-031
+ uc1=-2.5383028e-011       luc1=-8.9192166e-018      wuc1=-2.9125808e-017
+ puc1=1.6575302e-023       prt=0                     at=12741.287
+ lat=-0.0041913996         wat=-0.004166799          pat=3.2873434e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
     } 
ends nch3_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V PMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt pch3_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 xw= + 0 
+ + dxwp_3v ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg 
+ + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + 
+ (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) 
+ * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1e-005 / factor sb=1e-005 / factor sd=2 
+ * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_3v 
+ temp1=parp1_3v temp2=parp2_3v fac1=0.801230 * temp1 * sigma + 0.598357 * temp2 
+ * sigma fac2=0.801230 * temp1 * sigma - 0.598357 * temp2 * sigma lef=l * factor 
+ - 1.5e-08 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisp_3v=0.00399735 * geo_fac * fac1 * mismatchflag dlmisp_3v=0.00132084 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisp_3v= - 0.00132084 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisp_3v=0.00132084 * geo_fac * toxp_3v * fac2 * mismatchflag 
pch3_mac ( n1 n2 n3 n4 ) pch3 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model pch3 bsim4  { 
     1: type=p 
+ lmin=1e-005-(dxlp_3v+dlmisp_3v)                     lmax=0.00090001
+ wmin=1.003e-005-(dxwp_3v+dwmisp_3v)                 wmax=0.00090004
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71700001+(dvthp_3v+vthmisp_3v)
+ k1=0.83978                k2=0.062000001+dk2p_3v    k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13                nfactor=1                 eta0=0.09
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0135+du0p_3v
+ ua=2.32e-009              ub=-2.64e-019             uc=-5.1750001e-011
+ vsat=80000+dvsatp_3v      a0=0.97242                ags=0.1495
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0096207           dwg=0
+ dwb=0                     pclm=0.15                 pdiblc1=0
+ pdiblc2=0.000145          pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.2913
+ kt1l=0                    kt2=-0.055                ute=-1.1
+ ua1=1.2499e-009           ub1=-2.8921e-018          uc1=-9.5535e-011
+ prt=0                     at=160000                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  lvth0=0+dlvthp_3v         wvth0=0+dwvthp_3v
+ pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     2: type=p 
+ lmin=1.2e-006-(dxlp_3v+dlmisp_3v)                   lmax=1e-005-(dxlp_3v+dlmisp_3v)
+ wmin=1.003e-005-(dxwp_3v+dwmisp_3v)                 wmax=0.00090004
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71686717+(dvthp_3v+vthmisp_3v)
+ lvth0=-1.3242778e-009+dlvthp_3v                     k1=0.83978
+ k2=0.06219262+dk2p_3v     lk2=-1.920222e-009        k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.12946864          lvoff=-5.2971641e-009     nfactor=1
+ eta0=0.09                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.0135+du0p_3v         ua=2.3027307e-009         lua=1.7215783e-016
+ ub=-2.7688557e-019        lub=1.2845623e-025        uc=-5.7349245e-011
+ luc=5.5818867e-017        vsat=80000+dvsatp_3v      a0=0.98614645
+ la0=-1.3683899e-007       ags=0.13668085            lags=1.2779408e-007
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0073146748        lketa=-2.2988765e-008
+ dwg=0                     dwb=0                     pclm=0.14468636
+ lpclm=5.2971641e-008      pdiblc1=0                 pdiblc2=0.00011976023
+ lpdiblc2=2.5161529e-010   pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.2913
+ kt1l=0                    kt2=-0.055265682          lkt2=2.648582e-009
+ ute=-1.1033874            lute=3.3769421e-008       ua1=1.2405613e-009
+ lua1=9.3097659e-017       ub1=-2.827805e-018        lub1=-6.4095686e-025
+ uc1=-9.4689468e-011       luc1=-8.4291124e-018      prt=0
+ at=168701.08              lat=-0.086741055          jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  wvth0=0+dwvthp_3v         pvth0=0+dpvthp_3v
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     3: type=p 
+ lmin=5e-007-(dxlp_3v+dlmisp_3v)                     lmax=1.2e-006-(dxlp_3v+dlmisp_3v)
+ wmin=1.003e-005-(dxwp_3v+dwmisp_3v)                 wmax=0.00090004
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.708419+(dvthp_3v+vthmisp_3v)
+ lvth0=-1.1200189e-008+dlvthp_3v                     k1=0.83978
+ k2=0.059578502+dk2p_3v    lk2=1.1356827e-009        k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13467             lvoff=7.8323e-010         nfactor=1
+ eta0=0.09                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.011825+du0p_3v       lu0=1.958075e-009         ua=2.26709e-009
+ lua=2.1382179e-016        ub=-7.3047e-019           lub=6.5869643e-025
+ uc=-7.9326902e-011        luc=8.1510748e-017        vsat=80000+dvsatp_3v
+ a0=0.9913717              la0=-1.4294731e-007       ags=0.03562
+ lags=2.4593422e-007       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.015620821
+ lketa=-1.3278881e-008     dwg=0                     dwb=0
+ pclm=0.22685              lpclm=-4.307765e-008      pdiblc1=0
+ pdiblc2=0.00045225        lpdiblc2=-1.3706525e-010  pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.2913               kt1l=0                    kt2=-0.05501
+ lkt2=2.34969e-009         ute=-1.010515             lute=-7.4798465e-008
+ ua1=1.388272e-009         lua1=-7.9576168e-017      ub1=-3.0017709e-018
+ lub1=-4.3759068e-025      uc1=-8.19876e-011         luc1=-2.3277596e-017
+ prt=0                     at=137879.83              lat=-0.050711017
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  wvth0=0+dwvthp_3v
+ pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     4: type=p 
+ lmin=3e-07                lmax=5e-007-(dxlp_3v+dlmisp_3v)
+ wmin=1.003e-005-(dxwp_3v+dwmisp_3v)                 wmax=0.00090004
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.7246335+(dvthp_3v+vthmisp_3v)
+ lvth0=-3.5955885e-009+dlvthp_3v                     k1=0.83978
+ k2=0.04855+dk2p_3v        lk2=6.30805e-009          k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13031             lvoff=-1.26161e-009       nfactor=1
+ eta0=0.09                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.0112925+du0p_3v      lu0=2.2078175e-009        ua=3.008409e-009
+ lua=-1.3385682e-016       ub=-1.10947e-018          lub=8.3644743e-025
+ uc=-1.3977518e-010        luc=1.0986099e-016        vsat=80000+dvsatp_3v
+ a0=1.2065301              la0=-2.4385659e-007       ags=0.0489
+ lags=2.397059e-007        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.015109303
+ lketa=-1.3518783e-008     dwg=0                     dwb=0
+ pclm=-0.006225            lpclm=6.6234525e-008      pdiblc1=0
+ pdiblc2=-2.83e-005        lpdiblc2=8.83127e-011     pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.1962354            lkt1=-4.4585297e-008      kt1l=0
+ kt2=-0.056725             lkt2=3.154025e-009        ute=-0.9215785
+ lute=-1.1650968e-007      ua1=-1.1034079e-009       lua1=1.0890217e-015
+ ub1=-1.1351826e-018       lub1=-1.3130206e-024      uc1=1.86972e-011
+ luc1=-7.0498767e-017      prt=0                     at=63048.119
+ lat=-0.015614944          jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1e-005              sbref=1e-005              wlod=5e-006
+ kvth0=-1.8e-009           lkvth0=-1e-011            wkvth0=4e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=6.38e-008             lku0=2.55e-007            wku0=1e-008
+ pku0=-2.5e-013            llodku0=1                 wlodku0=1
+ kvsat=-1                  steta0=-3e-010            tku0=0.5
+ wvth0=0+dwvthp_3v         pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     5: type=p 
+ lmin=1e-005-(dxlp_3v+dlmisp_3v)                     lmax=0.00090001
+ wmin=1.23e-006-(dxwp_3v+dwmisp_3v)                  wmax=1.003e-005-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71488065+(dvthp_3v+vthmisp_3v)
+ wvth0=-2.1250845e-008+dwvthp_3v                     k1=0.83978
+ k2=0.060884547+dk2p_3v    wk2=1.1184661e-008        k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.12909369          wvoff=-9.0875385e-009     nfactor=1
+ eta0=0.092788636          weta0=-2.7961657e-008     etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013569716+du0p_3v    wu0=-6.9904142e-010
+ ua=2.3615507e-009         wua=-4.1662869e-016       ub=-2.7822205e-019
+ wub=1.4260445e-025        uc=-4.9657408e-011        wuc=-2.0982426e-017
+ vsat=80000+dvsatp_3v      a0=0.97625717             wa0=-3.8475296e-008
+ ags=0.15319494            wags=-3.7049195e-008      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.0095040932        wketa=-1.1692167e-009     dwg=0
+ dwb=0                     pclm=0.15                 pdiblc1=0
+ pdiblc2=0.00014249023     wpdiblc2=2.5165505e-011   pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.28886273           wkt1=-2.4438488e-008      kt1l=0
+ kt2=-0.055139432          wkt2=1.3980828e-009       ute=-1.0837144
+ wute=-1.6329608e-007      ua1=1.2089489e-009        wua1=4.1061693e-016
+ ub1=-2.768661e-018        wub1=-1.2377227e-024      uc1=-1.1017119e-010
+ wuc1=1.4675704e-016       prt=0                     at=160000
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  lvth0=0+dlvthp_3v         pvth0=0+dpvthp_3v
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     6: type=p 
+ lmin=1.2e-006-(dxlp_3v+dlmisp_3v)                   lmax=1e-005-(dxlp_3v+dlmisp_3v)
+ wmin=1.23e-006-(dxwp_3v+dwmisp_3v)                  wmax=1.003e-005-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71446627+(dvthp_3v+vthmisp_3v)
+ lvth0=-4.1309302e-009+dlvthp_3v                     wvth0=-2.4073827e-008+dwvthp_3v
+ pvth0=2.8142304e-014+dpvthp_3v                      k1=0.83978
+ k2=0.061055865+dk2p_3v    lk2=-1.7078764e-009       wk2=1.1398242e-008
+ pk2=-2.1291888e-015       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1283308
+ lvoff=-7.6052679e-009     wvoff=-1.1409071e-008     pvoff=2.3143357e-014
+ nfactor=1                 eta0=0.092788636          weta0=-2.7961657e-008
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.013578977+du0p_3v
+ lu0=-9.2324153e-011       wu0=-7.9190272e-010       pu0=9.2573428e-016
+ ua=2.3523719e-009         lua=9.1503453e-017        wua=-4.9775232e-016
+ pua=8.0872147e-022        ub=-2.9812755e-019        lub=1.9843794e-025
+ wub=2.1299332e-025        pub=-7.017066e-031        uc=-5.5482383e-011
+ luc=5.8069176e-017        wuc=-1.8719025e-017       puc=-2.2563848e-023
+ vsat=80000+dvsatp_3v      a0=0.99049335             la0=-1.4192051e-007
+ wa0=-4.3586382e-008       pa0=5.0952415e-014        ags=0.14041284
+ lags=1.2742479e-007       wags=-3.742064e-008       pags=3.7029371e-015
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0071825778        lketa=-2.3143187e-008
+ wketa=-1.3245365e-009     pketa=1.5483832e-015      dwg=0
+ dwb=0                     pclm=0.14468636           lpclm=5.2971641e-008
