+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0001
+ voff=-0.118               nfactor=1                 eta0=0.02
+ etab=-0.0001              u0=0.062+du0n_3vna        ua=1.4653e-009
+ ub=1.93e-018              uc=3.8334e-012            vsat=100000
+ a0=3.6                    ags=1.005                 a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.001               dwg=0                     dwb=0
+ pclm=0.5                  pdiblc1=0                 pdiblc2=0.0025
+ pdiblcb=0                 drout=0.588               pvag=0
+ delta=0.01                pscbe1=1e+9               pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=6.35e-010           bgidl=2.062e+009          cgidl=10
+ egidl=1.12                nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3vna            cgdo=cgon_3vna
+ cgbo=0                    cgdl=cgln_3vna            cgsl=cgln_3vna
+ clc=1e-007                cle=0.6                   cf=cfn_3vna
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=25                   noff=2.5845               voffcv=-0.041219
+ kt1=-0.29247              kt1l=0                    kt2=-0.020576
+ ute=-1.9498               ua1=4.2969e-010           ub1=-3.7159e-018
+ uc1=-3.975e-011           prt=0                     at=181930
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3vna       wvth0=0+dwvthn_3vna
+ pvth0=0+dpvthn_3vna       lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna
+ wk2=0+dwk2n_3vna          lvoff=0+dlvoffn_3vna      saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     2: type=n 
+ lmin=3e-006-(dxln_3vna+dlmisn_3vna)                 lmax=1e-005-(dxln_3vna+dlmisn_3vna)
+ wmin=1.003e-005-(dxwn_3vna+dwmisn_3vna)             wmax=0.00090001
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.076542064+(dvthn_3vna+vthmisn_3vna)
+ lvth0=4.1830092e-010+dlvthn_3vna                    k1=0.072
+ k2=0.0024877101+dk2n_3vna lk2=-1.1502857e-008       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=37.335
+ dvt1=0.3996               dvt2=0.096                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.07
+ minv=-0.5                 voffl=-2.6873e-010        dvtp0=1e-010
+ dvtp1=3.3836              lpe0=1e-010               lpeb=8.1978e-011
+ xj=1.4e-007               ngate=9.445e+019          ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0001
+ voff=-0.11774762          lvoff=-2.5098055e-009+dlvoffn_3vna
+ nfactor=1                 eta0=0.015793629          leta0=4.1830092e-008
+ etab=-0.0001              u0=0.061579363+du0n_3vna  lu0=4.1830092e-009+dlu0n_3vna
+ ua=1.5285218e-009         lua=-6.2870629e-016       ub=1.8185312e-018
+ lub=1.1084974e-024        uc=2.1413871e-012         luc=1.6826155e-017
+ vsat=100000               a0=4.6936566              la0=-1.0875824e-005
+ ags=0.17340037            lags=8.2698093e-006       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.001               dwg=0                     dwb=0
+ pclm=0.5                  pdiblc1=0                 pdiblc2=0.0021959214
+ lpdiblc2=3.0238974e-009   pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.28819212           lkt1=-4.2541204e-008
+ kt1l=0                    kt2=-0.022433954          lkt2=1.8476352e-008
+ ute=-1.9522397            lute=2.4261454e-008       ua1=5.3107617e-010
+ lua1=-1.0082307e-015      ub1=-4.04997e-018         lub1=3.3221459e-024
+ uc1=-4.2308315e-011       luc1=2.5441062e-017       prt=0
+ at=225656.91              lat=-0.43484054           jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ wvth0=0+dwvthn_3vna       pvth0=0+dpvthn_3vna       pu0=0+dpu0n_3vna
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wk2=0+dwk2n_3vna          pvoff=0+dpvoffn_3vna      fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=3e-006-(dxln_3vna+dlmisn_3vna)
+ wmin=1.003e-005-(dxwn_3vna+dwmisn_3vna)             wmax=0.00090001
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.076654324+(dvthn_3vna+vthmisn_3vna)
+ lvth0=7.4884815e-010+dlvthn_3vna                    k1=0.072
+ k2=-0.0052712159+dk2n_3vna                          lk2=1.134299e-008
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.1105252           lvoff=-2.3775929e-008+dlvoffn_3vna
+ nfactor=1                 eta0=0.027774661          leta0=6.5524213e-009
+ etab=-0.0015320374        letab=4.2165767e-009      u0=0.060456756+du0n_3vna
+ lu0=7.4884815e-009+dlu0n_3vna                       ua=1.1788093e-009
+ lua=4.0100819e-016        ub=2.2617602e-018         lub=-1.9657264e-025
+ uc=7.393411e-012          luc=1.3617804e-018        vsat=100000
+ a0=1.4450678              la0=-1.3104843e-006       ags=4.7158569
+ lags=-5.1052723e-006      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.0014586816
+ lketa=-7.2394895e-009     dwg=0                     dwb=0
+ pclm=0.75432444           lpclm=-7.4884815e-007     pdiblc1=0
+ pdiblc2=0.00082137785     lpdiblc2=7.0711859e-009   pdiblcb=0
+ drout=0.588               pvag=0                    delta=0.01
+ pscbe1=1e+9               pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=6.35e-010
+ bgidl=2.062e+009          cgidl=10                  egidl=1.12
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3vna            cgdo=cgon_3vna            cgbo=0
+ cgdl=cgln_3vna            cgsl=cgln_3vna            clc=1e-007
+ cle=0.6                   cf=cfn_3vna               ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=25
+ noff=2.5845               voffcv=-0.041219          kt1=-0.28081896
+ lkt1=-6.4251172e-008      kt1l=0                    kt2=-0.0069823382
+ lkt2=-2.7020314e-008      ute=-1.9677158            lute=6.983009e-008
+ ua1=1.5713649e-010        lua1=9.2819729e-017       ub1=-2.8265191e-018
+ lub1=-2.8025642e-025      uc1=-7.0524698e-011       luc1=1.0852307e-016
+ prt=0                     at=118677.45              lat=-0.11984379
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     wvth0=0+dwvthn_3vna       pvth0=0+dpvthn_3vna
+ pu0=0+dpu0n_3vna          wk2=0+dwk2n_3vna          saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     4: type=n 
+ lmin=1e-005-(dxln_3vna+dlmisn_3vna)                 lmax=0.00090001
+ wmin=1.23e-006-(dxwn_3vna+dwmisn_3vna)              wmax=1.003e-005-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.080505391+(dvthn_3vna+vthmisn_3vna)
+ wvth0=3.9985016e-008+dwvthn_3vna                    k1=0.072
+ k2=-0.0019444151+dk2n_3vna                          wk2=3.2697814e-008+dwk2n_3vna
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.11739516          wvoff=-6.0380058e-009
+ nfactor=1                 eta0=0.02                 etab=-0.0001
+ u0=0.062268818+du0n_3vna  wu0=-2.6835581e-009       ua=1.4622758e-009
+ wua=3.0190029e-017        ub=2.0131455e-018         wub=-8.3002453e-025
+ uc=4.0554438e-012         wuc=-2.216619e-018        vsat=100000
+ a0=3.8150545              wa0=-2.1468465e-006       ags=1.0148119
+ wags=-9.7949872e-008      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.0028978636
+ wketa=-3.8911593e-008     dwg=0                     dwb=0
+ pclm=0.5                  pdiblc1=0                 pdiblc2=0.0026623662
+ wpdiblc2=-1.6208691e-009  pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.28984499           wkt1=-2.6204945e-008
+ kt1l=0                    kt2=-0.020426134          wkt2=-1.4960837e-009
+ ute=-1.9523941            wute=2.5896336e-008       ua1=5.2041614e-010
+ wua1=-9.0570087e-016      ub1=-3.9206723e-018       wub1=2.0442004e-024
+ uc1=-4.5495989e-011       wuc1=5.7361055e-017       prt=0
+ at=180641.02              wat=0.012867661           jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3vna       pvth0=0+dpvthn_3vna       lu0=0+dlu0n_3vna
+ pu0=0+dpu0n_3vna          saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=1.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lvoff=0+dlvoffn_3vna      pvoff=0+dpvoffn_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     5: type=n 
+ lmin=3e-006-(dxln_3vna+dlmisn_3vna)                 lmax=1e-005-(dxln_3vna+dlmisn_3vna)
+ wmin=1.23e-006-(dxwn_3vna+dwmisn_3vna)              wmax=1.003e-005-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.08034392+(dvthn_3vna+vthmisn_3vna)
+ lvth0=-1.6057432e-009+dlvthn_3vna                   wvth0=3.7953169e-008+dwvthn_3vna
+ pvth0=2.0205627e-014+dpvthn_3vna                    k1=0.072
+ k2=-0.00070968902+dk2n_3vna                         lk2=-1.2278684e-008
+ wk2=3.1918996e-008+dwk2n_3vna                       pk2=7.7449292e-015
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.11708454          lvoff=-3.088907e-009+dlvoffn_3vna
+ wvoff=-6.61934e-009       pvoff=5.7810545e-015+dpvoffn_3vna
+ nfactor=1                 eta0=0.014730724          leta0=5.24001e-008
+ weta0=1.061076e-008       peta0=-1.0551828e-013     etab=-0.0001
+ u0=0.061791644+du0n_3vna  lu0=4.7452437e-009+dlu0n_3vna
+ wu0=-2.119156e-009        pu0=-5.6126743e-015+dpu0n_3vna
+ ua=1.5191145e-009         lua=-5.6523002e-016       wua=9.3911028e-017
+ pua=-6.3367092e-022       ub=1.9084385e-018         lub=1.0412542e-024
+ wub=-8.9752703e-025       pub=6.7127584e-031        uc=2.8022803e-012
+ luc=1.2462034e-017        wuc=-6.5975647e-018       puc=4.3566139e-023
+ vsat=100000               a0=5.0104785              la0=-1.1887846e-005
+ wa0=-3.1627703e-006       pa0=1.0102814e-011        ags=0.11005276
+ lags=8.9973407e-006       wags=6.3238647e-007       pags=-7.2628005e-012
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=0.0027847887         lketa=1.1244689e-009
+ wketa=-3.7782789e-008     pketa=-1.1225349e-014     dwg=0
+ dwb=0                     pclm=0.51130749           lpclm=-1.1244689e-007
+ wpclm=-1.1288042e-007     ppclm=1.1225349e-012      pdiblc1=0
+ pdiblc2=0.0024265848      lpdiblc2=2.3447181e-009   wpdiblc2=-2.3026669e-009
+ ppdiblc2=6.7801105e-015   pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.28499212           lkt1=-4.8259129e-008
+ wkt1=-3.1944915e-008      pkt1=5.7080897e-014       kt1l=0
+ kt2=-0.023568393          lkt2=3.124807e-008        wkt2=1.1324875e-008
+ pkt2=-1.2749751e-013      ute=-1.9475292            lute=-4.837924e-008
+ wute=-4.7024417e-008      pute=7.2515751e-013       ua1=7.0385512e-010
+ lua1=-1.8242016e-015      wua1=-1.7248177e-015      pua1=8.1456742e-021
+ ub1=-4.3937226e-018       lub1=4.7042307e-024       wub1=3.4316137e-024
+ pub1=-1.3797076e-029      uc1=-4.7465297e-011       luc1=1.9583704e-017
+ wuc1=5.1481114e-017       puc1=5.847284e-023        prt=0
+ at=223736.63              lat=-0.42856263           wat=0.019169775
+ pat=-6.2671121e-008       jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3vna              cjd=cjn_3vna
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3vna          cjswd=cjswn_3vna
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=0                 jtsswgd=0
+ njtsswg=60                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ xgw=0                     xgl=0                     fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=3e-006-(dxln_3vna+dlmisn_3vna)
+ wmin=1.23e-006-(dxwn_3vna+dwmisn_3vna)              wmax=1.003e-005-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.080408642+(dvthn_3vna+vthmisn_3vna)
+ lvth0=-1.4151698e-009+dlvthn_3vna                   wvth0=3.7478606e-008+dwvthn_3vna
+ pvth0=2.1602959e-014+dpvthn_3vna                    k1=0.072
+ k2=-0.0087414086+dk2n_3vna                          lk2=1.1370393e-008
+ wk2=3.464224e-008+dwk2n_3vna                        pk2=-2.7355375e-016
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.10948879          lvoff=-2.5454301e-008+dlvoffn_3vna
+ wvoff=-1.0346271e-008     pvoff=1.6754853e-014+dpvoffn_3vna
+ nfactor=1                 eta0=0.030070813          leta0=7.2318223e-009
+ weta0=-2.2922028e-008     peta0=-6.7823243e-015     etab=-0.0019638008
+ letab=5.487887e-009       wetab=4.3102083e-009      petab=-1.2691236e-014
+ u0=0.060945442+du0n_3vna  lu0=7.2368515e-009+dlu0n_3vna
+ wu0=-4.8784553e-009       pu0=2.511972e-015+dpu0n_3vna
+ ua=1.1890797e-009         lua=4.0654405e-016        wua=-1.0252823e-016
+ pua=-5.5263383e-023       ub=2.3319068e-018         lub=-2.0563132e-025
+ wub=-7.0026001e-025       pub=9.043099e-032         uc=5.6755244e-012
+ luc=4.0018823e-018        wuc=1.7149319e-017        puc=-2.635561e-023
+ vsat=100000               a0=1.3925483              la0=-1.2349953e-006
+ wa0=5.2429123e-007        pa0=-7.5359159e-013       ags=5.3150948
+ lags=-6.3286973e-006      wags=-5.9820719e-006      pags=1.2213208e-011
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=0.0065472928         lketa=-9.954074e-009
+ wketa=-5.0798589e-008     pketa=2.7099153e-014      dwg=0
+ dwb=0                     pclm=0.74453438           lpclm=-7.9917415e-007
+ wpclm=9.7732206e-008      ppclm=5.0239439e-013      pdiblc1=0
+ pdiblc2=0.00096129953     lpdiblc2=6.6591921e-009   wpdiblc2=-1.3968102e-009
+ ppdiblc2=4.1128517e-015   pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.27662795           lkt1=-7.2887113e-008
+ wkt1=-4.1838063e-008      pkt1=8.6210877e-014       kt1l=0
+ kt2=-0.0019394783         lkt2=-3.2437404e-008      wkt2=-5.0341862e-008
+ pkt2=5.4077732e-014       ute=-1.9977853            lute=9.9597919e-008
+ wute=3.0017806e-007       pute=-2.9716628e-013      ua1=-2.7832673e-011
+ lua1=3.3022383e-016       wua1=1.8465101e-015       pua1=-2.3699576e-021
+ ub1=-2.6144795e-018       lub1=-5.3467951e-025      wub1=-2.1167486e-024
+ pub1=2.5398548e-030       uc1=-8.3650342e-011       luc1=1.2612912e-016
+ wuc1=1.3103067e-016       puc1=-1.7575765e-022      prt=0
+ at=119065.75              lat=-0.1203634            wat=-0.0038763326
+ pat=5.1872221e-009        jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3vna              cjd=cjn_3vna
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3vna          cjswd=cjswn_3vna
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=0                 jtsswgd=0
+ njtsswg=60                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ xgw=0                     xgl=0                     fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     7: type=n 
+ lmin=1e-005-(dxln_3vna+dlmisn_3vna)                 lmax=0.00090001
+ wmin=5.3e-007-(dxwn_3vna+dwmisn_3vna)               wmax=1.23e-006-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.065115371+(dvthn_3vna+vthmisn_3vna)
+ wvth0=2.1781701e-008+dwvthn_3vna                    k1=0.072
+ k2=0.01189192+dk2n_3vna   wk2=1.6332197e-008+dwk2n_3vna
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.12043086          wvoff=-2.4473822e-009
+ nfactor=1                 eta0=0.026897143          weta0=-8.1579406e-009
+ etab=-0.0001              u0=0.058620571+du0n_3vna  wu0=1.6315881e-009
+ ua=1.7035426e-009         wua=-2.5518038e-016       ub=1.2149779e-018
+ wub=1.1404801e-025        uc=7.8787159e-012         wuc=-6.7387852e-018
+ vsat=100000               a0=2                      ags=1.0899446
+ wags=-1.8681684e-007      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.026649368
+ wketa=-3.9631275e-009     dwg=0                     dwb=0
+ pclm=0.5                  pdiblc1=0                 pdiblc2=0.0018520894
+ wpdiblc2=-6.6247372e-010  pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.31415191           wkt1=2.5452775e-009
+ kt1l=0                    kt2=-0.01099629           wkt2=-1.2649703e-008
+ ute=-2.0049891            wute=8.8105758e-008       ua1=-5.4583231e-010
+ wua1=3.5545779e-016       ub1=-2.0907361e-018       wub1=-1.2024804e-025
+ uc1=1.0498329e-012        wuc1=2.3066577e-018       prt=0
+ at=195692.77              wat=-0.004935554          jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3vna       pvth0=0+dpvthn_3vna       lu0=0+dlu0n_3vna
+ pu0=0+dpu0n_3vna          lvoff=0+dlvoffn_3vna      saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=3e-006-(dxln_3vna+dlmisn_3vna)                 lmax=1e-005-(dxln_3vna+dlmisn_3vna)
+ wmin=5.3e-007-(dxwn_3vna+dwmisn_3vna)               wmax=1.23e-006-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.066526669+(dvthn_3vna+vthmisn_3vna)
+ lvth0=1.4034594e-008+dlvthn_3vna                    wvth0=2.1610125e-008+dwvthn_3vna
+ pvth0=1.706237e-015+dpvthn_3vna                     k1=0.072
+ k2=0.012758312+dk2n_3vna  lk2=-8.6158039e-009       wk2=1.5989044e-008+dwk2n_3vna
+ pk2=3.4124741e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.1212587
+ lvoff=8.2324251e-009+dlvoffn_3vna                   wvoff=-1.6821504e-009
+ pvoff=-7.6098172e-015+dpvoffn_3vna                  nfactor=1
+ eta0=0.032426502          leta0=-5.4986493e-008     weta0=-1.0319806e-008
+ peta0=2.1498587e-014      etab=-0.0001              u0=0.058620571+du0n_3vna
+ wu0=1.6315881e-009        ua=1.8154728e-009         lua=-1.1130854e-015
+ wua=-2.5662162e-016       pua=1.4332391e-023        ub=1.05587e-018
+ lub=1.5822426e-024        wub=1.10891e-025          pub=3.1394762e-032
+ uc=1.4652178e-012         luc=6.3778776e-017        wuc=-5.0160871e-018
+ puc=-1.7131302e-023       vsat=100000               a0=2.3365097
+ la0=-3.3464074e-006       ags=0.75390934            lags=3.341689e-006
+ wags=-1.2916709e-007      pags=-5.7329565e-013      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.028570901         lketa=1.910861e-008       wketa=-6.9527883e-010
+ pketa=-3.2496991e-014     dwg=0                     dwb=0
+ pclm=0.35784868           lpclm=1.4136181e-006      wpclm=6.8630656e-008
+ ppclm=-6.8249482e-013     pdiblc1=0                 pdiblc2=0.00092068845
+ lpdiblc2=9.2622793e-009   wpdiblc2=-5.2149263e-010  ppdiblc2=-1.4019809e-015
+ pdiblcb=0                 drout=0.588               pvag=0
+ delta=0.01                pscbe1=1e+9               pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=6.35e-010           bgidl=2.062e+009          cgidl=10
+ egidl=1.12                nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3vna            cgdo=cgon_3vna
+ cgbo=0                    cgdl=cgln_3vna            cgsl=cgln_3vna
+ clc=1e-007                cle=0.6                   cf=cfn_3vna
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=25                   noff=2.5845               voffcv=-0.041219
+ kt1=-0.31505708           lkt1=9.0014534e-009       wkt1=3.6159157e-009
+ pkt1=-1.0646919e-014      kt1l=0                    kt2=-0.00029747541
+ lkt2=-1.0639394e-007      wkt2=-1.6199966e-008      pkt2=3.5305457e-014
+ ute=-2.0852748            lute=7.9839783e-007       wute=1.1590117e-007
+ pute=-2.764104e-013       ua1=-1.3139471e-009       lua1=7.6384865e-015
+ wua1=6.6183876e-016       pua1=-3.0467934e-021      ub1=-1.0337459e-018
+ lub1=-1.0511197e-023      wub1=-5.4256679e-025      pub1=4.1997319e-030
+ uc1=-1.3673859e-011       luc1=1.4641917e-016       wuc1=1.1512602e-017
+ puc1=-9.1548148e-023      prt=0                     at=251906.23
+ lat=-0.55901245           wat=-0.01414922           pat=9.1624929e-008
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ xgl=0                     lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=3e-006-(dxln_3vna+dlmisn_3vna)
+ wmin=5.3e-007-(dxwn_3vna+dwmisn_3vna)               wmax=1.23e-006-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.067570234+(dvthn_3vna+vthmisn_3vna)
+ lvth0=1.7107329e-008+dlvthn_3vna                    wvth0=2.2293337e-008+dwvthn_3vna
+ pvth0=-3.0545294e-016+dpvthn_3vna                   k1=0.072
+ k2=0.0063560992+dk2n_3vna lk2=1.0235257e-008        wk2=1.6784907e-008+dwk2n_3vna
+ pk2=1.0690853e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.11198453
+ lvoff=-1.9074992e-008+dlvoffn_3vna                  wvoff=-7.3943092e-009
+ pvoff=9.209406e-015+dpvoffn_3vna                    nfactor=1
+ eta0=0.012892472          leta0=2.5306788e-009      weta0=-2.6034853e-009
+ peta0=-1.2218117e-015     etab=0.0011540375         letab=-3.6924633e-009
+ wetab=6.2242911e-010      petab=-1.8327176e-015     u0=0.055441516+du0n_3vna
+ lu0=9.3606019e-009+dlu0n_3vna                       wu0=1.6315881e-009
+ pu0=4.0463074e-029+dpu0n_3vna                       ua=1.2941059e-009
+ lua=4.2205874e-016        wua=-2.2675314e-016       pua=-7.3614158e-023
+ ub=1.6739399e-018         lub=-2.3763947e-025       wub=7.7983277e-026
+ pub=1.2829023e-031        uc=2.4438622e-011         luc=-3.8654936e-018
+ wuc=-5.0436728e-018       puc=-1.7050077e-023       vsat=100000
+ a0=1.9235167              la0=-2.130366e-006        wa0=-1.0373819e-007
+ pa0=3.0545294e-013        ags=0.1485249             lags=5.1242192e-006
+ wags=1.2894694e-007       pags=-1.3333021e-012      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.029174668         lketa=2.0886377e-008      wketa=-8.5466534e-009
+ pketa=-9.3789324e-015     dwg=0                     dwb=0
+ pclm=1.0966635            lpclm=-7.6179253e-007     wpclm=-3.1876609e-007
+ ppclm=4.5817941e-013      pdiblc1=0                 pdiblc2=-0.0017505501
+ lpdiblc2=1.7127634e-008   wpdiblc2=1.8107656e-009   ppdiblc2=-8.2692219e-015
+ pdiblcb=0                 drout=0.588               pvag=0
+ delta=0.01                pscbe1=1e+9               pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=6.35e-010           bgidl=2.062e+009          cgidl=10
+ egidl=1.12                nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3vna            cgdo=cgon_3vna
+ cgbo=0                    cgdl=cgln_3vna            cgsl=cgln_3vna
+ clc=1e-007                cle=0.6                   cf=cfn_3vna
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=25                   noff=2.5845               voffcv=-0.041219
+ kt1=-0.32157745           lkt1=2.8200423e-008       wkt1=1.132821e-008
+ pkt1=-3.3355461e-014      kt1l=0                    kt2=-0.065267303
+ lkt2=8.4907121e-008       wkt2=2.4562288e-008       pkt2=-8.4717372e-014
+ ute=-1.7152606            lute=-2.9109439e-007      wute=-3.399218e-008
+ pute=1.6494459e-013       ua1=2.1570558e-009        lua1=-2.5817425e-015
+ wua1=-7.3777594e-016      pua1=1.0743162e-021       ub1=-5.3010125e-018
+ lub1=2.0535989e-024       wub1=1.0608827e-024       pub1=-5.2156089e-031
+ uc1=6.2758844e-011        luc1=-7.863387e-017       wuc1=-4.2142113e-017
+ puc1=6.6436014e-023       prt=0                     at=99087.546
+ lat=-0.10904396           wat=0.019753887           pat=-8.2014114e-009
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 xgw=0
+ xgl=0                     fnoimod=1                 noia=noian_3vna
+ noib=noibn_3vna           noic=noicn_3vna           em=4.10e7
+ ef=1.02                   minr=1e-3
 
 
 
     10: type=n 
+ lmin=1e-005-(dxln_3vna+dlmisn_3vna)                 lmax=0.00090001
+ wmin=2.2e-07              wmax=5.3e-007-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.0089858065+(dvthn_3vna+vthmisn_3vna)
+ wvth0=-1.3994347e-008+dwvthn_3vna                   k1=0.072
+ k2=0.020758761+dk2n_3vna  wk2=1.2051286e-008+dwk2n_3vna
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.096235484         wvoff=-1.4128908e-008
+ nfactor=1                 eta0=0.0092842735         weta0=3.4555273e-010
+ etab=-0.0001              u0=0.056425806+du0n_3vna  wu0=2.6912206e-009
+ ua=1.2091698e-009         wua=-1.6497183e-017       ub=1.482527e-018
+ wub=-1.512466e-026        uc=-1.8452037e-011        wuc=5.9737025e-018
+ vsat=100000               a0=2.1672258              wa0=-8.0736619e-008
+ ags=0.78605548            wags=-4.0099188e-008      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.018855048         wketa=-7.7262254e-009     dwg=0
+ dwb=0                     pclm=0.5                  pdiblc1=0
+ pdiblc2=0.0005245001      wpdiblc2=-2.1513618e-011  pdiblcb=0
+ drout=0.588               pvag=0                    delta=0.01
+ pscbe1=1e+9               pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=6.35e-010
+ bgidl=2.062e+009          cgidl=10                  egidl=1.12
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3vna            cgdo=cgon_3vna            cgbo=0
+ cgdl=cgln_3vna            cgsl=cgln_3vna            clc=1e-007
+ cle=0.6                   cf=cfn_3vna               ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=25
+ noff=2.5845               voffcv=-0.041219          kt1=-0.30714085
+ wkt1=-8.3966084e-010      kt1l=0                    kt2=-0.011191715
+ wkt2=-1.2555352e-008      ute=-1.7923994            wute=-1.4532591e-008
+ ua1=1.0043593e-009        wua1=-3.9297473e-016      ub1=-3.5957438e-018
+ wub1=6.0636969e-025       uc1=1.5764894e-011        wuc1=-4.7977736e-018
+ prt=0                     at=201562.7               wat=-0.007769554
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3vna       pvth0=0+dpvthn_3vna
+ lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna          saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 lvoff=0+dlvoffn_3vna
+ pvoff=0+dpvoffn_3vna      fnoimod=1                 noia=noian_3vna
+ noib=noibn_3vna           noic=noicn_3vna           em=4.10e7
+ ef=1.02                   minr=1e-3
 
 
 
     11: type=n 
+ lmin=3e-006-(dxln_3vna+dlmisn_3vna)                 lmax=1e-005-(dxln_3vna+dlmisn_3vna)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.0096341847+(dvthn_3vna+vthmisn_3vna)
+ lvth0=-6.4477714e-009+dlvthn_3vna                   wvth0=-1.5160336e-008+dwvthn_3vna
+ pvth0=1.1595123e-014+dpvthn_3vna                    k1=0.072
+ k2=0.019899136+dk2n_3vna  lk2=8.5485056e-009        wk2=1.2541454e-008+dwk2n_3vna
+ pk2=-4.8744546e-015       k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.093696355
+ lvoff=-2.5250263e-008+dlvoffn_3vna                  wvoff=-1.4989249e-008
+ pvoff=8.5556246e-015+dpvoffn_3vna                   nfactor=1
+ eta0=0.012965696          leta0=-3.6609762e-008     weta0=-9.2412916e-010
+ peta0=1.2626301e-014      etab=-0.0024212657        letab=2.3083734e-008
+ wetab=1.1207071e-009      petab=-1.1144827e-014     u0=0.056425806+du0n_3vna
+ wu0=2.6912206e-009        ua=1.3365959e-009         lua=-1.2671832e-015
+ wua=-2.5419822e-017       pua=8.8730833e-023        ub=1.2310167e-018
+ lub=2.501134e-024         wub=2.6330182e-026        pub=-4.1224602e-031
+ uc=-2.6701232e-011        luc=8.2033781e-017        wuc=8.5826746e-018
+ puc=-2.5944819e-023       vsat=100000               a0=2.5037355
+ la0=-3.3464074e-006       wa0=-8.0736619e-008       pa0=8.4418521e-028
+ ags=0.58607482            lags=1.9886997e-006       wags=-4.8136582e-008
+ pags=7.9927546e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.013531131
+ lketa=-5.2943474e-008     wketa=-7.9564797e-009     pketa=2.2897553e-015
+ dwg=0                     dwb=0                     pclm=0.57034139
+ lpclm=-6.9950709e-007     wpclm=-3.3960821e-008     ppclm=3.3772202e-013
+ pdiblc1=0                 pdiblc2=-9.6149958e-005   lpdiblc2=6.1720297e-009
+ wpdiblc2=-3.0563045e-011  ppdiblc2=8.9991662e-017   pdiblcb=0
+ drout=0.588               pvag=0                    delta=0.01
+ pscbe1=1e+9               pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=6.35e-010
+ bgidl=2.062e+009          cgidl=10                  egidl=1.12
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3vna            cgdo=cgon_3vna            cgbo=0
+ cgdl=cgln_3vna            cgsl=cgln_3vna            clc=1e-007
+ cle=0.6                   cf=cfn_3vna               ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=25
+ noff=2.5845               voffcv=-0.041219          kt1=-0.30509691
+ lkt1=-2.0325863e-008      wkt1=-1.1928534e-009      pkt1=3.5123091e-015
+ kt1l=0                    kt2=-0.0085526152         lkt2=-2.6244421e-008
+ wkt2=-1.2214385e-008      pkt2=-3.3907291e-015      ute=-1.7929562
+ lute=5.5377645e-009       wute=-2.523025e-008       pute=1.0638244e-013
+ ua1=1.0196999e-009        lua1=-1.5255424e-016      wua1=-4.6484602e-016
+ pua1=7.1472112e-022       ub1=-3.5760266e-018       lub1=-1.9607691e-025
+ wub1=6.8484635e-025       pub1=-7.8040806e-031      uc1=2.5414523e-011
+ luc1=-9.596035e-017       wuc1=-7.3592685e-018      puc1=2.5472684e-023
+ prt=0                     at=241304.35              lat=-0.39520926
+ wat=-0.0090306325         pat=1.2540745e-008        jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna          fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     12: type=n 
+ lmin=1.2e-06              lmax=3e-006-(dxln_3vna+dlmisn_3vna)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwn_3vna+dwmisn_3vna)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.0031960203+(dvthn_3vna+vthmisn_3vna)
+ lvth0=1.2509146e-008+dlvthn_3vna                    wvth0=-1.1872611e-008+dwvthn_3vna
+ pvth0=1.9145498e-015+dpvthn_3vna                    k1=0.072
+ k2=0.019477997+dk2n_3vna  lk2=9.7885324e-009        wk2=1.0449655e-008+dwk2n_3vna
+ pk2=1.2847637e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.10652483
+ lvoff=1.2522674e-008+dlvoffn_3vna                   wvoff=-1.0030251e-008
+ pvoff=-6.0459468e-015+dpvoffn_3vna                  nfactor=1
+ eta0=-0.0030118761        leta0=1.0435561e-008      weta0=5.0751338e-009
+ peta0=-5.038289e-015      etab=0.010641062          letab=-1.5377766e-008
+ wetab=-3.9579061e-009     petab=3.8089465e-015      u0=0.054309991+du0n_3vna
+ lu0=6.2299335e-009+dlu0n_3vna                       wu0=2.1778882e-009
+ pu0=1.5114867e-015+dpu0n_3vna                       ua=8.2381399e-010
+ lua=2.4268246e-016        wua=3.0378218e-019        pua=1.2988709e-023
+ ub=1.9654433e-018         lub=3.3864411e-025        wub=-6.2754586e-026
+ pub=-1.4993948e-031       uc=1.8535956e-011         luc=-5.1165309e-017
+ wuc=-2.1938659e-018       puc=5.7862734e-024        vsat=100000
+ a0=1.9396691              la0=-1.6855364e-006       wa0=-1.1153656e-007
+ pa0=9.0689203e-014        ags=1.0785997             lags=5.384798e-007
+ wags=-3.200932e-007       pags=8.8069292e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.031688445         lketa=5.2000982e-010      wketa=-7.3330019e-009
+ pketa=4.5394984e-016      dwg=0                     dwb=0
+ pclm=0.1983104            lpclm=3.9592327e-007      wpclm=1.1495878e-007
+ ppclm=-1.0076578e-013     pdiblc1=0                 pdiblc2=0.0048353074
+ lpdiblc2=-8.3484491e-009  wpdiblc2=-1.3688864e-009  ppdiblc2=4.0306312e-015
+ pdiblcb=0                 drout=0.588               pvag=0
+ delta=0.01                pscbe1=1e+9               pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=6.35e-010           bgidl=2.062e+009          cgidl=10
+ egidl=1.12                nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3vna            cgdo=cgon_3vna
+ cgbo=0                    cgdl=cgln_3vna            cgsl=cgln_3vna
+ clc=1e-007                cle=0.6                   cf=cfn_3vna
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=25                   noff=2.5845               voffcv=-0.041219
+ kt1=-0.2903735            lkt1=-6.3678375e-008      wkt1=-3.7370598e-009
+ pkt1=1.1003623e-014       kt1l=0                    kt2=0.030893537
+ lkt2=-1.4239204e-007      wkt2=-2.1864165e-008      pkt2=2.5022662e-014
+ ute=-1.8273807            lute=1.0689928e-007       wute=2.0139427e-008
+ pute=-2.7206761e-014      ua1=1.0439861e-009        lua1=-2.2406373e-016
+ wua1=-2.0038588e-016      pua1=-6.3971156e-023      ub1=-3.9424561e-018
+ lub1=8.8285994e-025       wub1=4.0497162e-025       pub1=4.3671889e-032
+ uc1=-6.5055016e-011       luc1=1.7042359e-016       wuc1=1.9566419e-017
+ puc1=-5.3808927e-023      prt=0                     at=160794.69
+ lat=-0.1581518            wat=-0.010038325          pat=1.5507854e-008
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 xgw=0
+ xgl=0                     fnoimod=1                 noia=noian_3vna
+ noib=noibn_3vna           noic=noicn_3vna           em=4.10e7
+ ef=1.02                   minr=1e-3
 
 
 
     } 
ends nanch3_mac
// 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V Native NMOS DEVICE MODELS          
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
model nanch3 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_3vna     lmax=0.00090001           wmin=1.003e-005-dxwn_3vna
+ wmax=0.00090001           version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.0765+dvthn_3vna   k1=0.072
+ k2=0.001331+dk2n_3vna     k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.118
+ nfactor=1                 eta0=0.02                 etab=-0.0001
+ u0=0.062+du0n_3vna        ua=1.4653e-009            ub=1.93e-018
+ uc=3.8334e-012            vsat=100000               a0=3.6
+ ags=1.005                 a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.001
+ dwg=0                     dwb=0                     pclm=0.5
+ pdiblc1=0                 pdiblc2=0.0025            pdiblcb=0
+ drout=0.588               pvag=0                    delta=0.01
+ pscbe1=1e+9               pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=6.35e-010
+ bgidl=2.062e+009          cgidl=10                  egidl=1.12
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3vna            cgdo=cgon_3vna            cgbo=0
+ cgdl=cgln_3vna            cgsl=cgln_3vna            clc=1e-007
+ cle=0.6                   cf=cfn_3vna               ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=25
+ noff=2.5845               voffcv=-0.041219          kt1=-0.29247
+ kt1l=0                    kt2=-0.020576             ute=-1.9498
+ ua1=4.2969e-010           ub1=-3.7159e-018          uc1=-3.975e-011
+ prt=0                     at=181930                 jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3vna       wvth0=0+dwvthn_3vna       pvth0=0+dpvthn_3vna
+ lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna          wk2=0+dwk2n_3vna
+ lvoff=0+dlvoffn_3vna      saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=1.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pvoff=0+dpvoffn_3vna      fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     2: type=n 
+ lmin=3e-006-dxln_3vna     lmax=1e-005-dxln_3vna     wmin=1.003e-005-dxwn_3vna
+ wmax=0.00090001           version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.076542064+dvthn_3vna
+ lvth0=4.1830092e-010+dlvthn_3vna                    k1=0.072
+ k2=0.0024877101+dk2n_3vna lk2=-1.1502857e-008       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=37.335
+ dvt1=0.3996               dvt2=0.096                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.07
+ minv=-0.5                 voffl=-2.6873e-010        dvtp0=1e-010
+ dvtp1=3.3836              lpe0=1e-010               lpeb=8.1978e-011
+ xj=1.4e-007               ngate=9.445e+019          ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0001
+ voff=-0.11774762          lvoff=-2.5098055e-009+dlvoffn_3vna
+ nfactor=1                 eta0=0.015793629          leta0=4.1830092e-008
+ etab=-0.0001              u0=0.061579363+du0n_3vna  lu0=4.1830092e-009+dlu0n_3vna
+ ua=1.5285218e-009         lua=-6.2870629e-016       ub=1.8185312e-018
+ lub=1.1084974e-024        uc=2.1413871e-012         luc=1.6826155e-017
+ vsat=100000               a0=4.6936566              la0=-1.0875824e-005
+ ags=0.17340037            lags=8.2698093e-006       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.001               dwg=0                     dwb=0
+ pclm=0.5                  pdiblc1=0                 pdiblc2=0.0021959214
+ lpdiblc2=3.0238974e-009   pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.28819212           lkt1=-4.2541204e-008
+ kt1l=0                    kt2=-0.022433954          lkt2=1.8476352e-008
+ ute=-1.9522397            lute=2.4261454e-008       ua1=5.3107617e-010
+ lua1=-1.0082307e-015      ub1=-4.04997e-018         lub1=3.3221459e-024
+ uc1=-4.2308315e-011       luc1=2.5441062e-017       prt=0
+ at=225656.91              lat=-0.43484054           jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ wvth0=0+dwvthn_3vna       pvth0=0+dpvthn_3vna       pu0=0+dpu0n_3vna
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wk2=0+dwk2n_3vna          pvoff=0+dpvoffn_3vna      fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=3e-006-dxln_3vna     wmin=1.003e-005-dxwn_3vna
+ wmax=0.00090001           version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.076654324+dvthn_3vna
+ lvth0=7.4884815e-010+dlvthn_3vna                    k1=0.072
+ k2=-0.0052712159+dk2n_3vna                          lk2=1.134299e-008
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.1105252           lvoff=-2.3775929e-008+dlvoffn_3vna
+ nfactor=1                 eta0=0.027774661          leta0=6.5524213e-009
+ etab=-0.0015320374        letab=4.2165767e-009      u0=0.060456756+du0n_3vna
+ lu0=7.4884815e-009+dlu0n_3vna                       ua=1.1788093e-009
+ lua=4.0100819e-016        ub=2.2617602e-018         lub=-1.9657264e-025
+ uc=7.393411e-012          luc=1.3617804e-018        vsat=100000
+ a0=1.4450678              la0=-1.3104843e-006       ags=4.7158569
+ lags=-5.1052723e-006      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.0014586816
+ lketa=-7.2394895e-009     dwg=0                     dwb=0
+ pclm=0.75432444           lpclm=-7.4884815e-007     pdiblc1=0
+ pdiblc2=0.00082137785     lpdiblc2=7.0711859e-009   pdiblcb=0
+ drout=0.588               pvag=0                    delta=0.01
+ pscbe1=1e+9               pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=6.35e-010
+ bgidl=2.062e+009          cgidl=10                  egidl=1.12
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3vna            cgdo=cgon_3vna            cgbo=0
+ cgdl=cgln_3vna            cgsl=cgln_3vna            clc=1e-007
+ cle=0.6                   cf=cfn_3vna               ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=25
+ noff=2.5845               voffcv=-0.041219          kt1=-0.28081896
+ lkt1=-6.4251172e-008      kt1l=0                    kt2=-0.0069823382
+ lkt2=-2.7020314e-008      ute=-1.9677158            lute=6.983009e-008
+ ua1=1.5713649e-010        lua1=9.2819729e-017       ub1=-2.8265191e-018
+ lub1=-2.8025642e-025      uc1=-7.0524698e-011       luc1=1.0852307e-016
+ prt=0                     at=118677.45              lat=-0.11984379
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     wvth0=0+dwvthn_3vna       pvth0=0+dpvthn_3vna
+ pu0=0+dpu0n_3vna          wk2=0+dwk2n_3vna          saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     4: type=n 
+ lmin=1e-005-dxln_3vna     lmax=0.00090001           wmin=1.23e-006-dxwn_3vna
+ wmax=1.003e-005-dxwn_3vna version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.080505391+dvthn_3vna
+ wvth0=3.9985016e-008+dwvthn_3vna                    k1=0.072
+ k2=-0.0019444151+dk2n_3vna                          wk2=3.2697814e-008+dwk2n_3vna
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.11739516          wvoff=-6.0380058e-009
+ nfactor=1                 eta0=0.02                 etab=-0.0001
+ u0=0.062268818+du0n_3vna  wu0=-2.6835581e-009       ua=1.4622758e-009
+ wua=3.0190029e-017        ub=2.0131455e-018         wub=-8.3002453e-025
+ uc=4.0554438e-012         wuc=-2.216619e-018        vsat=100000
+ a0=3.8150545              wa0=-2.1468465e-006       ags=1.0148119
+ wags=-9.7949872e-008      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.0028978636
+ wketa=-3.8911593e-008     dwg=0                     dwb=0
+ pclm=0.5                  pdiblc1=0                 pdiblc2=0.0026623662
+ wpdiblc2=-1.6208691e-009  pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.28984499           wkt1=-2.6204945e-008
+ kt1l=0                    kt2=-0.020426134          wkt2=-1.4960837e-009
+ ute=-1.9523941            wute=2.5896336e-008       ua1=5.2041614e-010
+ wua1=-9.0570087e-016      ub1=-3.9206723e-018       wub1=2.0442004e-024
+ uc1=-4.5495989e-011       wuc1=5.7361055e-017       prt=0
+ at=180641.02              wat=0.012867661           jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3vna       pvth0=0+dpvthn_3vna       lu0=0+dlu0n_3vna
+ pu0=0+dpu0n_3vna          saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=1.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lvoff=0+dlvoffn_3vna      pvoff=0+dpvoffn_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     5: type=n 
+ lmin=3e-006-dxln_3vna     lmax=1e-005-dxln_3vna     wmin=1.23e-006-dxwn_3vna
+ wmax=1.003e-005-dxwn_3vna version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.08034392+dvthn_3vna
+ lvth0=-1.6057432e-009+dlvthn_3vna                   wvth0=3.7953169e-008+dwvthn_3vna
+ pvth0=2.0205627e-014+dpvthn_3vna                    k1=0.072
+ k2=-0.00070968902+dk2n_3vna                         lk2=-1.2278684e-008
+ wk2=3.1918996e-008+dwk2n_3vna                       pk2=7.7449292e-015
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.11708454          lvoff=-3.088907e-009+dlvoffn_3vna
+ wvoff=-6.61934e-009       pvoff=5.7810545e-015+dpvoffn_3vna
+ nfactor=1                 eta0=0.014730724          leta0=5.24001e-008
+ weta0=1.061076e-008       peta0=-1.0551828e-013     etab=-0.0001
+ u0=0.061791644+du0n_3vna  lu0=4.7452437e-009+dlu0n_3vna
+ wu0=-2.119156e-009        pu0=-5.6126743e-015+dpu0n_3vna
+ ua=1.5191145e-009         lua=-5.6523002e-016       wua=9.3911028e-017
+ pua=-6.3367092e-022       ub=1.9084385e-018         lub=1.0412542e-024
+ wub=-8.9752703e-025       pub=6.7127584e-031        uc=2.8022803e-012
+ luc=1.2462034e-017        wuc=-6.5975647e-018       puc=4.3566139e-023
+ vsat=100000               a0=5.0104785              la0=-1.1887846e-005
+ wa0=-3.1627703e-006       pa0=1.0102814e-011        ags=0.11005276
+ lags=8.9973407e-006       wags=6.3238647e-007       pags=-7.2628005e-012
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=0.0027847887         lketa=1.1244689e-009
+ wketa=-3.7782789e-008     pketa=-1.1225349e-014     dwg=0
+ dwb=0                     pclm=0.51130749           lpclm=-1.1244689e-007
+ wpclm=-1.1288042e-007     ppclm=1.1225349e-012      pdiblc1=0
+ pdiblc2=0.0024265848      lpdiblc2=2.3447181e-009   wpdiblc2=-2.3026669e-009
+ ppdiblc2=6.7801105e-015   pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.28499212           lkt1=-4.8259129e-008
+ wkt1=-3.1944915e-008      pkt1=5.7080897e-014       kt1l=0
+ kt2=-0.023568393          lkt2=3.124807e-008        wkt2=1.1324875e-008
+ pkt2=-1.2749751e-013      ute=-1.9475292            lute=-4.837924e-008
+ wute=-4.7024417e-008      pute=7.2515751e-013       ua1=7.0385512e-010
+ lua1=-1.8242016e-015      wua1=-1.7248177e-015      pua1=8.1456742e-021
+ ub1=-4.3937226e-018       lub1=4.7042307e-024       wub1=3.4316137e-024
+ pub1=-1.3797076e-029      uc1=-4.7465297e-011       luc1=1.9583704e-017
+ wuc1=5.1481114e-017       puc1=5.847284e-023        prt=0
+ at=223736.63              lat=-0.42856263           wat=0.019169775
+ pat=-6.2671121e-008       jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3vna              cjd=cjn_3vna
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3vna          cjswd=cjswn_3vna
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=0                 jtsswgd=0
+ njtsswg=60                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ xgw=0                     xgl=0                     fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=3e-006-dxln_3vna     wmin=1.23e-006-dxwn_3vna
+ wmax=1.003e-005-dxwn_3vna version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.080408642+dvthn_3vna
+ lvth0=-1.4151698e-009+dlvthn_3vna                   wvth0=3.7478606e-008+dwvthn_3vna
+ pvth0=2.1602959e-014+dpvthn_3vna                    k1=0.072
+ k2=-0.0087414086+dk2n_3vna                          lk2=1.1370393e-008
+ wk2=3.464224e-008+dwk2n_3vna                        pk2=-2.7355375e-016
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.10948879          lvoff=-2.5454301e-008+dlvoffn_3vna
+ wvoff=-1.0346271e-008     pvoff=1.6754853e-014+dpvoffn_3vna
+ nfactor=1                 eta0=0.030070813          leta0=7.2318223e-009
+ weta0=-2.2922028e-008     peta0=-6.7823243e-015     etab=-0.0019638008
+ letab=5.487887e-009       wetab=4.3102083e-009      petab=-1.2691236e-014
+ u0=0.060945442+du0n_3vna  lu0=7.2368515e-009+dlu0n_3vna
+ wu0=-4.8784553e-009       pu0=2.511972e-015+dpu0n_3vna
+ ua=1.1890797e-009         lua=4.0654405e-016        wua=-1.0252823e-016
+ pua=-5.5263383e-023       ub=2.3319068e-018         lub=-2.0563132e-025
+ wub=-7.0026001e-025       pub=9.043099e-032         uc=5.6755244e-012
+ luc=4.0018823e-018        wuc=1.7149319e-017        puc=-2.635561e-023
+ vsat=100000               a0=1.3925483              la0=-1.2349953e-006
+ wa0=5.2429123e-007        pa0=-7.5359159e-013       ags=5.3150948
+ lags=-6.3286973e-006      wags=-5.9820719e-006      pags=1.2213208e-011
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=0.0065472928         lketa=-9.954074e-009
+ wketa=-5.0798589e-008     pketa=2.7099153e-014      dwg=0
+ dwb=0                     pclm=0.74453438           lpclm=-7.9917415e-007
+ wpclm=9.7732206e-008      ppclm=5.0239439e-013      pdiblc1=0
+ pdiblc2=0.00096129953     lpdiblc2=6.6591921e-009   wpdiblc2=-1.3968102e-009
+ ppdiblc2=4.1128517e-015   pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.27662795           lkt1=-7.2887113e-008
+ wkt1=-4.1838063e-008      pkt1=8.6210877e-014       kt1l=0
+ kt2=-0.0019394783         lkt2=-3.2437404e-008      wkt2=-5.0341862e-008
+ pkt2=5.4077732e-014       ute=-1.9977853            lute=9.9597919e-008
+ wute=3.0017806e-007       pute=-2.9716628e-013      ua1=-2.7832673e-011
+ lua1=3.3022383e-016       wua1=1.8465101e-015       pua1=-2.3699576e-021
+ ub1=-2.6144795e-018       lub1=-5.3467951e-025      wub1=-2.1167486e-024
+ pub1=2.5398548e-030       uc1=-8.3650342e-011       luc1=1.2612912e-016
+ wuc1=1.3103067e-016       puc1=-1.7575765e-022      prt=0
+ at=119065.75              lat=-0.1203634            wat=-0.0038763326
+ pat=5.1872221e-009        jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3vna              cjd=cjn_3vna
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3vna          cjswd=cjswn_3vna
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=0                 jtsswgd=0
+ njtsswg=60                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ xgw=0                     xgl=0                     fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     7: type=n 
+ lmin=1e-005-dxln_3vna     lmax=0.00090001           wmin=5.3e-007-dxwn_3vna
+ wmax=1.23e-006-dxwn_3vna  version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.065115371+dvthn_3vna
+ wvth0=2.1781701e-008+dwvthn_3vna                    k1=0.072
+ k2=0.01189192+dk2n_3vna   wk2=1.6332197e-008+dwk2n_3vna
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.12043086          wvoff=-2.4473822e-009
+ nfactor=1                 eta0=0.026897143          weta0=-8.1579406e-009
+ etab=-0.0001              u0=0.058620571+du0n_3vna  wu0=1.6315881e-009
+ ua=1.7035426e-009         wua=-2.5518038e-016       ub=1.2149779e-018
+ wub=1.1404801e-025        uc=7.8787159e-012         wuc=-6.7387852e-018
+ vsat=100000               a0=2                      ags=1.0899446
+ wags=-1.8681684e-007      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.026649368
+ wketa=-3.9631275e-009     dwg=0                     dwb=0
+ pclm=0.5                  pdiblc1=0                 pdiblc2=0.0018520894
+ wpdiblc2=-6.6247372e-010  pdiblcb=0                 drout=0.588
+ pvag=0                    delta=0.01                pscbe1=1e+9
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=6.35e-010           bgidl=2.062e+009
+ cgidl=10                  egidl=1.12                nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3vna
+ cgdo=cgon_3vna            cgbo=0                    cgdl=cgln_3vna
+ cgsl=cgln_3vna            clc=1e-007                cle=0.6
+ cf=cfn_3vna               ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=25                   noff=2.5845
+ voffcv=-0.041219          kt1=-0.31415191           wkt1=2.5452775e-009
+ kt1l=0                    kt2=-0.01099629           wkt2=-1.2649703e-008
+ ute=-2.0049891            wute=8.8105758e-008       ua1=-5.4583231e-010
+ wua1=3.5545779e-016       ub1=-2.0907361e-018       wub1=-1.2024804e-025
+ uc1=1.0498329e-012        wuc1=2.3066577e-018       prt=0
+ at=195692.77              wat=-0.004935554          jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3vna       pvth0=0+dpvthn_3vna       lu0=0+dlu0n_3vna
+ pu0=0+dpu0n_3vna          lvoff=0+dlvoffn_3vna      saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=3e-006-dxln_3vna     lmax=1e-005-dxln_3vna     wmin=5.3e-007-dxwn_3vna
+ wmax=1.23e-006-dxwn_3vna  version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.066526669+dvthn_3vna
+ lvth0=1.4034594e-008+dlvthn_3vna                    wvth0=2.1610125e-008+dwvthn_3vna
+ pvth0=1.706237e-015+dpvthn_3vna                     k1=0.072
+ k2=0.012758312+dk2n_3vna  lk2=-8.6158039e-009       wk2=1.5989044e-008+dwk2n_3vna
+ pk2=3.4124741e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.1212587
+ lvoff=8.2324251e-009+dlvoffn_3vna                   wvoff=-1.6821504e-009
+ pvoff=-7.6098172e-015+dpvoffn_3vna                  nfactor=1
+ eta0=0.032426502          leta0=-5.4986493e-008     weta0=-1.0319806e-008
+ peta0=2.1498587e-014      etab=-0.0001              u0=0.058620571+du0n_3vna
+ wu0=1.6315881e-009        ua=1.8154728e-009         lua=-1.1130854e-015
+ wua=-2.5662162e-016       pua=1.4332391e-023        ub=1.05587e-018
+ lub=1.5822426e-024        wub=1.10891e-025          pub=3.1394762e-032
+ uc=1.4652178e-012         luc=6.3778776e-017        wuc=-5.0160871e-018
+ puc=-1.7131302e-023       vsat=100000               a0=2.3365097
+ la0=-3.3464074e-006       ags=0.75390934            lags=3.341689e-006
+ wags=-1.2916709e-007      pags=-5.7329565e-013      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.028570901         lketa=1.910861e-008       wketa=-6.9527883e-010
+ pketa=-3.2496991e-014     dwg=0                     dwb=0
+ pclm=0.35784868           lpclm=1.4136181e-006      wpclm=6.8630656e-008
+ ppclm=-6.8249482e-013     pdiblc1=0                 pdiblc2=0.00092068845
+ lpdiblc2=9.2622793e-009   wpdiblc2=-5.2149263e-010  ppdiblc2=-1.4019809e-015
+ pdiblcb=0                 drout=0.588               pvag=0
+ delta=0.01                pscbe1=1e+9               pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=6.35e-010           bgidl=2.062e+009          cgidl=10
+ egidl=1.12                nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3vna            cgdo=cgon_3vna
+ cgbo=0                    cgdl=cgln_3vna            cgsl=cgln_3vna
+ clc=1e-007                cle=0.6                   cf=cfn_3vna
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=25                   noff=2.5845               voffcv=-0.041219
+ kt1=-0.31505708           lkt1=9.0014534e-009       wkt1=3.6159157e-009
+ pkt1=-1.0646919e-014      kt1l=0                    kt2=-0.00029747541
+ lkt2=-1.0639394e-007      wkt2=-1.6199966e-008      pkt2=3.5305457e-014
+ ute=-2.0852748            lute=7.9839783e-007       wute=1.1590117e-007
+ pute=-2.764104e-013       ua1=-1.3139471e-009       lua1=7.6384865e-015
+ wua1=6.6183876e-016       pua1=-3.0467934e-021      ub1=-1.0337459e-018
+ lub1=-1.0511197e-023      wub1=-5.4256679e-025      pub1=4.1997319e-030
+ uc1=-1.3673859e-011       luc1=1.4641917e-016       wuc1=1.1512602e-017
+ puc1=-9.1548148e-023      prt=0                     at=251906.23
+ lat=-0.55901245           wat=-0.01414922           pat=9.1624929e-008
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ xgl=0                     lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna
+ fnoimod=1                 noia=noian_3vna           noib=noibn_3vna
+ noic=noicn_3vna           em=4.10e7                 ef=1.02
+ minr=1e-3
 
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=3e-006-dxln_3vna     wmin=5.3e-007-dxwn_3vna
+ wmax=1.23e-006-dxwn_3vna  version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.067570234+dvthn_3vna
+ lvth0=1.7107329e-008+dlvthn_3vna                    wvth0=2.2293337e-008+dwvthn_3vna
+ pvth0=-3.0545294e-016+dpvthn_3vna                   k1=0.072
+ k2=0.0063560992+dk2n_3vna lk2=1.0235257e-008        wk2=1.6784907e-008+dwk2n_3vna
+ pk2=1.0690853e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.11198453
+ lvoff=-1.9074992e-008+dlvoffn_3vna                  wvoff=-7.3943092e-009
+ pvoff=9.209406e-015+dpvoffn_3vna                    nfactor=1
+ eta0=0.012892472          leta0=2.5306788e-009      weta0=-2.6034853e-009
+ peta0=-1.2218117e-015     etab=0.0011540375         letab=-3.6924633e-009
+ wetab=6.2242911e-010      petab=-1.8327176e-015     u0=0.055441516+du0n_3vna
+ lu0=9.3606019e-009+dlu0n_3vna                       wu0=1.6315881e-009
+ pu0=4.0463074e-029+dpu0n_3vna                       ua=1.2941059e-009
+ lua=4.2205874e-016        wua=-2.2675314e-016       pua=-7.3614158e-023
+ ub=1.6739399e-018         lub=-2.3763947e-025       wub=7.7983277e-026
+ pub=1.2829023e-031        uc=2.4438622e-011         luc=-3.8654936e-018
+ wuc=-5.0436728e-018       puc=-1.7050077e-023       vsat=100000
+ a0=1.9235167              la0=-2.130366e-006        wa0=-1.0373819e-007
+ pa0=3.0545294e-013        ags=0.1485249             lags=5.1242192e-006
+ wags=1.2894694e-007       pags=-1.3333021e-012      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.029174668         lketa=2.0886377e-008      wketa=-8.5466534e-009
+ pketa=-9.3789324e-015     dwg=0                     dwb=0
+ pclm=1.0966635            lpclm=-7.6179253e-007     wpclm=-3.1876609e-007
+ ppclm=4.5817941e-013      pdiblc1=0                 pdiblc2=-0.0017505501
+ lpdiblc2=1.7127634e-008   wpdiblc2=1.8107656e-009   ppdiblc2=-8.2692219e-015
+ pdiblcb=0                 drout=0.588               pvag=0
+ delta=0.01                pscbe1=1e+9               pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=6.35e-010           bgidl=2.062e+009          cgidl=10
+ egidl=1.12                nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3vna            cgdo=cgon_3vna
+ cgbo=0                    cgdl=cgln_3vna            cgsl=cgln_3vna
+ clc=1e-007                cle=0.6                   cf=cfn_3vna
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=25                   noff=2.5845               voffcv=-0.041219
+ kt1=-0.32157745           lkt1=2.8200423e-008       wkt1=1.132821e-008
+ pkt1=-3.3355461e-014      kt1l=0                    kt2=-0.065267303
+ lkt2=8.4907121e-008       wkt2=2.4562288e-008       pkt2=-8.4717372e-014
+ ute=-1.7152606            lute=-2.9109439e-007      wute=-3.399218e-008
+ pute=1.6494459e-013       ua1=2.1570558e-009        lua1=-2.5817425e-015
+ wua1=-7.3777594e-016      pua1=1.0743162e-021       ub1=-5.3010125e-018
+ lub1=2.0535989e-024       wub1=1.0608827e-024       pub1=-5.2156089e-031
+ uc1=6.2758844e-011        luc1=-7.863387e-017       wuc1=-4.2142113e-017
+ puc1=6.6436014e-023       prt=0                     at=99087.546
+ lat=-0.10904396           wat=0.019753887           pat=-8.2014114e-009
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 xgw=0
+ xgl=0                     fnoimod=1                 noia=noian_3vna
+ noib=noibn_3vna           noic=noicn_3vna           em=4.10e7
+ ef=1.02                   minr=1e-3
 
 
 
     10: type=n 
+ lmin=1e-005-dxln_3vna     lmax=0.00090001           wmin=2.2e-07
+ wmax=5.3e-007-dxwn_3vna   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.0089858065+dvthn_3vna
+ wvth0=-1.3994347e-008+dwvthn_3vna                   k1=0.072
+ k2=0.020758761+dk2n_3vna  wk2=1.2051286e-008+dwk2n_3vna
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=37.335               dvt1=0.3996               dvt2=0.096
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.07                 minv=-0.5                 voffl=-2.6873e-010
+ dvtp0=1e-010              dvtp1=3.3836              lpe0=1e-010
+ lpeb=8.1978e-011          xj=1.4e-007               ngate=9.445e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0001                voff=-0.096235484         wvoff=-1.4128908e-008
+ nfactor=1                 eta0=0.0092842735         weta0=3.4555273e-010
+ etab=-0.0001              u0=0.056425806+du0n_3vna  wu0=2.6912206e-009
+ ua=1.2091698e-009         wua=-1.6497183e-017       ub=1.482527e-018
+ wub=-1.512466e-026        uc=-1.8452037e-011        wuc=5.9737025e-018
+ vsat=100000               a0=2.1672258              wa0=-8.0736619e-008
+ ags=0.78605548            wags=-4.0099188e-008      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.018855048         wketa=-7.7262254e-009     dwg=0
+ dwb=0                     pclm=0.5                  pdiblc1=0
+ pdiblc2=0.0005245001      wpdiblc2=-2.1513618e-011  pdiblcb=0
+ drout=0.588               pvag=0                    delta=0.01
+ pscbe1=1e+9               pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=6.35e-010
+ bgidl=2.062e+009          cgidl=10                  egidl=1.12
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3vna            cgdo=cgon_3vna            cgbo=0
+ cgdl=cgln_3vna            cgsl=cgln_3vna            clc=1e-007
+ cle=0.6                   cf=cfn_3vna               ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=25
+ noff=2.5845               voffcv=-0.041219          kt1=-0.30714085
+ wkt1=-8.3966084e-010      kt1l=0                    kt2=-0.011191715
+ wkt2=-1.2555352e-008      ute=-1.7923994            wute=-1.4532591e-008
+ ua1=1.0043593e-009        wua1=-3.9297473e-016      ub1=-3.5957438e-018
+ wub1=6.0636969e-025       uc1=1.5764894e-011        wuc1=-4.7977736e-018
+ prt=0                     at=201562.7               wat=-0.007769554
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3vna       pvth0=0+dpvthn_3vna
+ lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna          saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 lvoff=0+dlvoffn_3vna
+ pvoff=0+dpvoffn_3vna      fnoimod=1                 noia=noian_3vna
+ noib=noibn_3vna           noic=noicn_3vna           em=4.10e7
+ ef=1.02                   minr=1e-3
 
 
 
     11: type=n 
+ lmin=3e-006-dxln_3vna     lmax=1e-005-dxln_3vna     wmin=2.2e-07
+ wmax=5.3e-007-dxwn_3vna   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.0096341847+dvthn_3vna
+ lvth0=-6.4477714e-009+dlvthn_3vna                   wvth0=-1.5160336e-008+dwvthn_3vna
+ pvth0=1.1595123e-014+dpvthn_3vna                    k1=0.072
+ k2=0.019899136+dk2n_3vna  lk2=8.5485056e-009        wk2=1.2541454e-008+dwk2n_3vna
+ pk2=-4.8744546e-015       k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.093696355
+ lvoff=-2.5250263e-008+dlvoffn_3vna                  wvoff=-1.4989249e-008
+ pvoff=8.5556246e-015+dpvoffn_3vna                   nfactor=1
+ eta0=0.012965696          leta0=-3.6609762e-008     weta0=-9.2412916e-010
+ peta0=1.2626301e-014      etab=-0.0024212657        letab=2.3083734e-008
+ wetab=1.1207071e-009      petab=-1.1144827e-014     u0=0.056425806+du0n_3vna
+ wu0=2.6912206e-009        ua=1.3365959e-009         lua=-1.2671832e-015
+ wua=-2.5419822e-017       pua=8.8730833e-023        ub=1.2310167e-018
+ lub=2.501134e-024         wub=2.6330182e-026        pub=-4.1224602e-031
+ uc=-2.6701232e-011        luc=8.2033781e-017        wuc=8.5826746e-018
+ puc=-2.5944819e-023       vsat=100000               a0=2.5037355
+ la0=-3.3464074e-006       wa0=-8.0736619e-008       pa0=8.4418521e-028
+ ags=0.58607482            lags=1.9886997e-006       wags=-4.8136582e-008
+ pags=7.9927546e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.013531131
+ lketa=-5.2943474e-008     wketa=-7.9564797e-009     pketa=2.2897553e-015
+ dwg=0                     dwb=0                     pclm=0.57034139
+ lpclm=-6.9950709e-007     wpclm=-3.3960821e-008     ppclm=3.3772202e-013
+ pdiblc1=0                 pdiblc2=-9.6149958e-005   lpdiblc2=6.1720297e-009
+ wpdiblc2=-3.0563045e-011  ppdiblc2=8.9991662e-017   pdiblcb=0
+ drout=0.588               pvag=0                    delta=0.01
+ pscbe1=1e+9               pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=6.35e-010
+ bgidl=2.062e+009          cgidl=10                  egidl=1.12
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3vna            cgdo=cgon_3vna            cgbo=0
+ cgdl=cgln_3vna            cgsl=cgln_3vna            clc=1e-007
+ cle=0.6                   cf=cfn_3vna               ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=25
+ noff=2.5845               voffcv=-0.041219          kt1=-0.30509691
+ lkt1=-2.0325863e-008      wkt1=-1.1928534e-009      pkt1=3.5123091e-015
+ kt1l=0                    kt2=-0.0085526152         lkt2=-2.6244421e-008
+ wkt2=-1.2214385e-008      pkt2=-3.3907291e-015      ute=-1.7929562
+ lute=5.5377645e-009       wute=-2.523025e-008       pute=1.0638244e-013
+ ua1=1.0196999e-009        lua1=-1.5255424e-016      wua1=-4.6484602e-016
+ pua1=7.1472112e-022       ub1=-3.5760266e-018       lub1=-1.9607691e-025
+ wub1=6.8484635e-025       pub1=-7.8040806e-031      uc1=2.5414523e-011
+ luc1=-9.596035e-017       wuc1=-7.3592685e-018      puc1=2.5472684e-023
+ prt=0                     at=241304.35              lat=-0.39520926
+ wat=-0.0090306325         pat=1.2540745e-008        jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3vna
+ cjd=cjn_3vna              mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3vna
+ cjswd=cjswn_3vna          mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3vna
+ cjswgd=cjswgn_3vna        mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=0
+ jtsswgd=0                 njtsswg=60                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=1.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ lu0=0+dlu0n_3vna          pu0=0+dpu0n_3vna          fnoimod=1
+ noia=noian_3vna           noib=noibn_3vna           noic=noicn_3vna
+ em=4.10e7                 ef=1.02                   minr=1e-3
 
 
 
     12: type=n 
+ lmin=1.2e-06              lmax=3e-006-dxln_3vna     wmin=2.2e-07
+ wmax=5.3e-007-dxwn_3vna   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3vna            toxm=6.693e-009           dtox=5.5408e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_3vna     xw=0+dxwn_3vna
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.0031960203+dvthn_3vna
+ lvth0=1.2509146e-008+dlvthn_3vna                    wvth0=-1.1872611e-008+dwvthn_3vna
+ pvth0=1.9145498e-015+dpvthn_3vna                    k1=0.072
+ k2=0.019477997+dk2n_3vna  lk2=9.7885324e-009        wk2=1.0449655e-008+dwk2n_3vna
+ pk2=1.2847637e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=37.335               dvt1=0.3996
+ dvt2=0.096                dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.07                 minv=-0.5
+ voffl=-2.6873e-010        dvtp0=1e-010              dvtp1=3.3836
+ lpe0=1e-010               lpeb=8.1978e-011          xj=1.4e-007
+ ngate=9.445e+019          ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0001                voff=-0.10652483
+ lvoff=1.2522674e-008+dlvoffn_3vna                   wvoff=-1.0030251e-008
+ pvoff=-6.0459468e-015+dpvoffn_3vna                  nfactor=1
+ eta0=-0.0030118761        leta0=1.0435561e-008      weta0=5.0751338e-009
+ peta0=-5.038289e-015      etab=0.010641062          letab=-1.5377766e-008
+ wetab=-3.9579061e-009     petab=3.8089465e-015      u0=0.054309991+du0n_3vna
+ lu0=6.2299335e-009+dlu0n_3vna                       wu0=2.1778882e-009
+ pu0=1.5114867e-015+dpu0n_3vna                       ua=8.2381399e-010
+ lua=2.4268246e-016        wua=3.0378218e-019        pua=1.2988709e-023
+ ub=1.9654433e-018         lub=3.3864411e-025        wub=-6.2754586e-026
+ pub=-1.4993948e-031       uc=1.8535956e-011         luc=-5.1165309e-017
+ wuc=-2.1938659e-018       puc=5.7862734e-024        vsat=100000
+ a0=1.9396691              la0=-1.6855364e-006       wa0=-1.1153656e-007
+ pa0=9.0689203e-014        ags=1.0785997             lags=5.384798e-007
+ wags=-3.200932e-007       pags=8.8069292e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.031688445         lketa=5.2000982e-010      wketa=-7.3330019e-009
+ pketa=4.5394984e-016      dwg=0                     dwb=0
+ pclm=0.1983104            lpclm=3.9592327e-007      wpclm=1.1495878e-007
+ ppclm=-1.0076578e-013     pdiblc1=0                 pdiblc2=0.0048353074
+ lpdiblc2=-8.3484491e-009  wpdiblc2=-1.3688864e-009  ppdiblc2=4.0306312e-015
+ pdiblcb=0                 drout=0.588               pvag=0
+ delta=0.01                pscbe1=1e+9               pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=6.35e-010           bgidl=2.062e+009          cgidl=10
+ egidl=1.12                nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3vna            cgdo=cgon_3vna
+ cgbo=0                    cgdl=cgln_3vna            cgsl=cgln_3vna
+ clc=1e-007                cle=0.6                   cf=cfn_3vna
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=25                   noff=2.5845               voffcv=-0.041219
+ kt1=-0.2903735            lkt1=-6.3678375e-008      wkt1=-3.7370598e-009
+ pkt1=1.1003623e-014       kt1l=0                    kt2=0.030893537
+ lkt2=-1.4239204e-007      wkt2=-2.1864165e-008      pkt2=2.5022662e-014
+ ute=-1.8273807            lute=1.0689928e-007       wute=2.0139427e-008
+ pute=-2.7206761e-014      ua1=1.0439861e-009        lua1=-2.2406373e-016
+ wua1=-2.0038588e-016      pua1=-6.3971156e-023      ub1=-3.9424561e-018
+ lub1=8.8285994e-025       wub1=4.0497162e-025       pub1=4.3671889e-032
+ uc1=-6.5055016e-011       luc1=1.7042359e-016       wuc1=1.9566419e-017
+ puc1=-5.3808927e-023      prt=0                     at=160794.69
+ lat=-0.1581518            wat=-0.010038325          pat=1.5507854e-008
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3vna              cjd=cjn_3vna              mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3vna          cjswd=cjswn_3vna          mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3vna        cjswgd=cjswgn_3vna        mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=0                 jtsswgd=0                 njtsswg=60
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=1.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 xgw=0
+ xgl=0                     fnoimod=1                 noia=noian_3vna
+ noib=noibn_3vna           noic=noicn_3vna           em=4.10e7
+ ef=1.02                   minr=1e-3
 
 
 
 
     } 
endsection mos_3vna
 
// *********************************************************************************************
// **********************************
//                                  *
//     1.8V PNP AND NPN bipolar     *
//                                  *
// **********************************

section tt_bip
include "cmn018_assp_v1d2.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters isa=1
parameters bfa=1
parameters nfa=1
parameters rba=1
parameters rea=1
parameters rca=1
parameters rbma=1
parameters cjea=1
parameters cjca=1
include "cmn018_assp_v1d2.scs" section=bip
endsection tt_bip
 

section ss_bip
include "cmn018_assp_v1d2.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters isa=0.70
parameters bfa=0.85
parameters nfa=0.9975
parameters rba=1.2
parameters rea=1.2
parameters rca=1.2
parameters rbma=1.2
parameters cjea=1.05
parameters cjca=1.05
include "cmn018_assp_v1d2.scs" section=bip
endsection ss_bip
 

section ff_bip
include "cmn018_assp_v1d2.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters isa=1.30
parameters bfa=1.15
parameters nfa=1.0025
parameters rba=0.8
parameters rea=0.8
parameters rca=0.8
parameters rbma=0.8
parameters cjea=0.95
parameters cjca=0.95
include "cmn018_assp_v1d2.scs" section=bip
endsection ff_bip
 

section mc_bip
include "cmn018_assp_v1d2.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters par1mc_bip=0
parameters a1mc_bip=par1mc_bip * 3.0000e+000 * 3 / 3
parameters isa=1.0000e+000 + ( - 1.0000e-001) * a1mc_bip
parameters bfa=1.0000e+000 + ( - 5.0000e-002) * a1mc_bip
parameters nfa=1.0000e+000 + ( - 1.6667e-003) * a1mc_bip
parameters rba=1.0000e+000 + (6.6667e-002) * a1mc_bip
parameters rea=1.0000e+000 + (6.6667e-002) * a1mc_bip
parameters rca=1.0000e+000 + (6.6667e-002) * a1mc_bip
parameters rbma=1.0000e+000 + (6.6667e-002) * a1mc_bip
parameters cjea=1.0000e+000 + (1.6667e-002) * a1mc_bip
parameters cjca=1.0000e+000 + (1.6667e-002) * a1mc_bip

statistics {
    process {
        vary par1mc_bip dist=gauss std=1/3
        }
    }
 
 
include "cmn018_assp_v1d2.scs" section=bip
endsection mc_bip
 

section bip
// 
model pnp5 bjt type=pnp 
+ bf=2.775*bfa              nf=1.013*nfa              is=3.5351e-18*isa
+ ise=3.5351e-18*isa        isc=3.5351e-18*isa        ne=1.3977142
+ rb=54.76734*rba           irb=1.401332e-3           rbm=1.0965611*rbma
+ re=1.3979963*rea          ikf=8.2254e-4             nkf=0.477972
+ vaf=372.731               br=4.4013e-3              nr=0.993881
+ nc=0.98076                rc=20.08*rca              ikr=1.98804e-4
+ var=20.84541              xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-2.512025e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=4.9e-3
+ tbf2=1.1e-6               tnf1=-1.056025e-4         tne1=2.152336e-4
+ tvaf1=-4e-5               tbr1=-1.01e-3             tbr2=1.3e-5
+ tnc1=1.122277e-4          tnc2=0                    tnr1=-1.026101e-4
+ tnr2=0                    cje=3.069e-14*cjea        vje=0.86
+ mje=0.44                  fc=0                      cjc=3.965e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.18e-4               ctc=2.8425e-3
+ tvje=1.61e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
model pnp10 bjt type=pnp 
+ bf=2.715*bfa              nf=1.01*nfa               is=1.5353e-17*isa
+ ise=1.5353e-17*isa        isc=1.5353e-17*isa        ne=1.2977142
+ rb=36.063401*rba          irb=1.401332e-3           rbm=1.0965611*rbma
+ re=1.3979963*rea          ikf=1.72254e-3            nkf=0.477972
+ vaf=361.145               br=0.0114433              nr=0.9908706
+ nc=0.9007513              rc=20.08*rca              ikr=1.98804e-4
+ var=20.84541              xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-3.912025e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=4.91e-3
+ tbf2=1e-6                 tnf1=-1.0025e-4           tne1=2.00234e-4
+ tvaf1=-5e-3               tbr1=-3.15e-3             tbr2=3.5e-5
+ tnc1=8.022278e-5          tnc2=0                    tnr1=-2.025978e-4
+ tnr2=0                    cje=1.174e-13*cjea        vje=0.86
+ mje=0.44                  fc=0                      cjc=6.838e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.18e-4               ctc=2.8425e-3
+ tvje=1.61e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
model pnp2 bjt type=pnp 
+ bf=2.7551*bfa             nf=1.013*nfa              is=9.03515e-19*isa
+ ise=9.03515e-19*isa       isc=9.03515e-19*isa       ne=1.2977142
+ rb=102.76734*rba          irb=1.401332e-3           rbm=1.0965611*rbma
+ re=1.297997*rea           ikf=3.02541e-4            nkf=0.427981
+ vaf=126.168               br=1.3713e-3              nr=0.993671
+ nc=0.920748               rc=20.08*rca              ikr=1.98804e-4
+ var=15.6151               xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-4.31203e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=5.85e-3
+ tbf2=3e-6                 tnf1=-1.056025e-4         tne1=2.152336e-4
+ tvaf1=-1e-3               tbr1=-1.5e-3              tbr2=1.85e-5
+ tnc1=1.122198e-4          tnc2=0                    tnr1=-2.425601e-4
+ tnr2=0                    cje=5.556e-15*cjea        vje=0.86
+ mje=0.44                  fc=0                      cjc=2.563e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.18e-4               ctc=2.8425e-3
+ tvje=1.61e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
model npn10 bjt type=npn 
+ bf=25.7*bfa               nf=1.01*nfa               ise=2.88886e-17*isa
+ ne=1.22                   is=2.88886e-17*isa        rb=30*rba
+ irb=1e-3                  rbm=1.5*rbma              re=20*rea
+ ikf=0.0134151             nkf=0.4538405             vaf=46.5899168
+ br=2.95                   nr=0.9886811              tlev=1
+ isc=2.88886e-17*isa       nc=1.0197608              rc=12*rca
+ ikr=3.753206e-3           var=27.600531             xti=3
+ eg=1.17                   xtb=0                     tbf1=6.1e-3
+ tbf2=8e-6                 trb1=0.0118               tikf1=-5e-3
+ tikr1=5e-3                tbr1=4.5e-3               tbr2=-1e-6
+ tne1=5e-4                 cje=1.028e-13*cjea        vje=0.6882682
+ mje=0.359                 cte=9.05e-4               tvje=1.49e-3
+ cjc=2.082e-13*cjca        vjc=0.585                 mjc=0.35
+ ctc=1e-3                  tvjc=1.40e-3              tlevc=1
+ fc=0                      tnom=25                   rbmod=spice
+ minr=1e-3
//                                                                            
//      
model npn5 bjt type=npn 
+ bf=26.7*bfa               nf=1.013*nfa              ise=8.45141e-18*isa
+ ne=1.22                   is=8.45141e-18*isa        rb=30*rba
+ irb=1e-3                  rbm=1.5*rbma              re=25*rea
+ ikf=8.03653e-3            nkf=0.5097973             vaf=46.4089369
+ br=0.98                   nr=0.987839               tlev=1
+ isc=8.45141e-18*isa       nc=1.0244644              rc=15*rca
+ ikr=4e-3                  var=28.110846             xti=3
+ eg=1.17                   xtb=0                     tbf1=6.4e-3
+ tbf2=1e-5                 trb1=0.0118               tikf1=-6e-3
+ tikr1=5e-3                trc1=8e-4                 tbr1=1.9e-3
+ tbr2=-5e-6                tne1=4.6e-4               cje=2.69e-14*cjea
+ vje=0.6882682             mje=0.359                 cte=9.05e-4
+ tvje=1.49e-3              cjc=1.057e-13*cjca        vjc=0.585
+ mjc=0.35                  ctc=1e-3                  tvjc=1.40e-3
+ tlevc=1                   fc=0                      tnom=25
+ rbmod=spice               minr=1e-3
//                                                                            
//      
model npn2 bjt type=npn 
+ bf=28.2*bfa               nf=1.012*nfa              ise=1.970838e-18*isa
+ ne=1.22                   is=1.970838e-18*isa       rb=40*rba
+ irb=1e-3                  rbm=2.0*rbma              re=30*rea
+ ikf=3.25342e-3            nkf=0.5554402             vaf=47.6877977
+ br=0.302                  nr=0.9869396              tlev=1
+ isc=1.970838e-18          nc=1.0205444              rc=20*rca
+ ikr=4.740015e-3           var=28.292768             xti=3
+ eg=1.17                   xtb=0                     tbf1=7.2e-3
+ tbf2=1.2e-5               tikf1=-5e-3               tbr1=1.4e-3
+ tbr2=-5e-6                tne1=2e-4                 cje=4.872e-15*cjea
+ vje=0.6882682             mje=0.359                 cte=9.05e-4
+ tvje=1.49e-3              cjc=6.058e-14*cjca        vjc=0.585
+ mjc=0.35                  ctc=1e-3                  tvjc=1.40e-3
+ tlevc=1                   fc=0                      tnom=25
+ rbmod=spice               minr=1e-3
// 
 
// ************************************************
//                                                *
//     1.8V PNP AND NPN bipolar Mismatch Model    *
//                                                *
// ************************************************
// 
 
subckt pnp5_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis5=1 + 0.31e-2 * (1 / sqrt(multi 
+ * 5e-6 * 5e-6 * 1e12)) * par_bjtp1 * mismatchflag bfmis5=1 + 1.1405e-2 * (1 / 
+ sqrt(multi * 5e-6 * 5e-6 * 1e12)) * par_bjtp2 * mismatchflag 
qin ( c b e ) pnp5 m=multi
model pnp5 bjt type=pnp 
+ bf=2.775*bfa*bfmis5       nf=1.013*nfa              is=3.5351e-18*isa*ismis5
+ ise=3.5351e-18*isa        isc=3.5351e-18*isa        ne=1.3977142
+ rb=54.76734*rba           irb=1.401332e-3           rbm=1.0965611*rbma
+ re=1.3979963*rea          ikf=8.2254e-4             nkf=0.477972
+ vaf=372.731               br=4.4013e-3              nr=0.993881
+ nc=0.98076                rc=20.08*rca              ikr=1.98804e-4
+ var=20.84541              xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-2.512025e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=4.9e-3
+ tbf2=1.1e-6               tnf1=-1.056025e-4         tne1=2.152336e-4
+ tvaf1=-4e-5               tbr1=-1.01e-3             tbr2=1.3e-5
+ tnc1=1.122277e-4          tnc2=0                    tnr1=-1.026101e-4
+ tnr2=0                    cje=3.069e-14*cjea        vje=0.86
+ mje=0.44                  fc=0                      cjc=3.965e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.18e-4               ctc=2.8425e-3
+ tvje=1.61e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
ends pnp5_mis
// 
// 
subckt pnp10_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis10=1 + 0.31e-2 * (1 / sqrt(multi 
+ * 10e-6 * 10e-6 * 1e12)) * par_bjtp1 * mismatchflag bfmis10=1 + 1.1405e-2 * (1 
+ / sqrt(multi * 10e-6 * 10e-6 * 1e12)) * par_bjtp2 * mismatchflag 
qin ( c b e ) pnp10 m=multi
model pnp10 bjt type=pnp 
+ bf=2.715*bfa*bfmis10      nf=1.01*nfa               is=1.5353e-17*isa*ismis10
+ ise=1.5353e-17*isa        isc=1.5353e-17*isa        ne=1.2977142
+ rb=36.063401*rba          irb=1.401332e-3           rbm=1.0965611*rbma
+ re=1.3979963*rea          ikf=1.72254e-3            nkf=0.477972
+ vaf=361.145               br=0.0114433              nr=0.9908706
+ nc=0.9007513              rc=20.08*rca              ikr=1.98804e-4
+ var=20.84541              xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-3.912025e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=4.91e-3
+ tbf2=1e-6                 tnf1=-1.0025e-4           tne1=2.00234e-4
+ tvaf1=-5e-3               tbr1=-3.15e-3             tbr2=3.5e-5
+ tnc1=8.022278e-5          tnc2=0                    tnr1=-2.025978e-4
+ tnr2=0                    cje=1.174e-13*cjea        vje=0.86
+ mje=0.44                  fc=0                      cjc=6.838e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.18e-4               ctc=2.8425e-3
+ tvje=1.61e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
ends pnp10_mis
// 
// 
subckt pnp2_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis2=1 + 0.31e-2 * (1 / sqrt(multi 
+ * 2e-6 * 2e-6 * 1e12)) * par_bjtp1 * mismatchflag bfmis2=1 + 1.1405e-2 * (1 / 
+ sqrt(multi * 2e-6 * 2e-6 * 1e12)) * par_bjtp2 * mismatchflag 
qin ( c b e ) pnp2 m=multi
model pnp2 bjt type=pnp 
+ bf=2.7551*bfa*bfmis2      nf=1.013*nfa              is=9.03515e-19*isa*ismis2
+ ise=9.03515e-19*isa       isc=9.03515e-19*isa       ne=1.2977142
+ rb=102.76734*rba          irb=1.401332e-3           rbm=1.0965611*rbma
+ re=1.297997*rea           ikf=3.02541e-4            nkf=0.427981
+ vaf=126.168               br=1.3713e-3              nr=0.993671
+ nc=0.920748               rc=20.08*rca              ikr=1.98804e-4
+ var=15.6151               xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-4.31203e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=5.85e-3
+ tbf2=3e-6                 tnf1=-1.056025e-4         tne1=2.152336e-4
+ tvaf1=-1e-3               tbr1=-1.5e-3              tbr2=1.85e-5
+ tnc1=1.122198e-4          tnc2=0                    tnr1=-2.425601e-4
+ tnr2=0                    cje=5.556e-15*cjea        vje=0.86
+ mje=0.44                  fc=0                      cjc=2.563e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.18e-4               ctc=2.8425e-3
+ tvje=1.61e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
ends pnp2_mis
// 
// 
subckt npn10_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis10=1 + 0.16461e-2 * (1 / sqrt(multi 
+ * 10e-6 * 10e-6 * 1e12)) * par_bjtn1 * mismatchflag bfmis10=1 + 3.868e-2 * (1 
+ / sqrt(multi * 10e-6 * 10e-6 * 1e12)) * par_bjtn2 * mismatchflag 
qin ( c b e ) npn10 m=multi
model npn10 bjt type=npn 
+ bf=25.7*bfa*bfmis10       nf=1.01*nfa               ise=2.88886e-17*isa
+ ne=1.22                   is=2.88886e-17*isa*ismis10
+ rb=30*rba                 irb=1e-3                  rbm=1.5*rbma
+ re=20*rea                 ikf=0.0134151             nkf=0.4538405
+ vaf=46.5899168            br=2.95                   nr=0.9886811
+ tlev=1                    isc=2.88886e-17*isa       nc=1.0197608
+ rc=12*rca                 ikr=3.753206e-3           var=27.600531
+ xti=3                     eg=1.17                   xtb=0
+ tbf1=6.1e-3               tbf2=8e-6                 trb1=0.0118
+ tikf1=-5e-3               tikr1=5e-3                tbr1=4.5e-3
+ tbr2=-1e-6                tne1=5e-4                 cje=1.028e-13*cjea
+ vje=0.6882682             mje=0.359                 cte=9.05e-4
+ tvje=1.49e-3              cjc=2.082e-13*cjca        vjc=0.585
+ mjc=0.35                  ctc=1e-3                  tvjc=1.40e-3
+ tlevc=1                   fc=0                      tnom=25
+ rbmod=spice               minr=1e-3
ends npn10_mis
// 
// 
subckt npn5_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis5=1 + 0.16461e-2 * (1 / sqrt(multi 
+ * 5e-6 * 5e-6 * 1e12)) * par_bjtn1 * mismatchflag bfmis5=1 + 3.868e-2 * (1 / sqrt(multi 
+ * 5e-6 * 5e-6 * 1e12)) * par_bjtn2 * mismatchflag 
qin ( c b e ) npn5 m=multi
model npn5 bjt type=npn 
+ bf=26.7*bfa*bfmis5        nf=1.013*nfa              ise=8.45141e-18*isa
+ ne=1.22                   is=8.45141e-18*isa*ismis5 rb=30*rba
+ irb=1e-3                  rbm=1.5*rbma              re=25*rea
+ ikf=8.03653e-3            nkf=0.5097973             vaf=46.4089369
+ br=0.98                   nr=0.987839               tlev=1
+ isc=8.45141e-18*isa       nc=1.0244644              rc=15*rca
+ ikr=4e-3                  var=28.110846             xti=3
+ eg=1.17                   xtb=0                     tbf1=6.4e-3
+ tbf2=1e-5                 trb1=0.0118               tikf1=-6e-3
+ tikr1=5e-3                trc1=8e-4                 tbr1=1.9e-3
+ tbr2=-5e-6                tne1=4.6e-4               cje=2.69e-14*cjea
+ vje=0.6882682             mje=0.359                 cte=9.05e-4
+ tvje=1.49e-3              cjc=1.057e-13*cjca        vjc=0.585
+ mjc=0.35                  ctc=1e-3                  tvjc=1.40e-3
+ tlevc=1                   fc=0                      tnom=25
+ rbmod=spice               minr=1e-3
//  
ends npn5_mis
// 
// 
subckt npn2_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis2=1 + 0.16461e-2 * (1 / sqrt(multi 
+ * 2e-6 * 2e-6 * 1e12)) * par_bjtn1 * mismatchflag bfmis2=1 + 3.868e-2 * (1 / sqrt(multi 
+ * 2e-6 * 2e-6 * 1e12)) * par_bjtn2 * mismatchflag 
qin ( c b e ) npn2 m=multi
model npn2 bjt type=npn 
+ bf=28.2*bfa*bfmis2        nf=1.012*nfa              ise=1.970838e-18*isa
+ ne=1.22                   is=1.970838e-18*isa*ismis2
+ rb=40*rba                 irb=1e-3                  rbm=2.0*rbma
+ re=30*rea                 ikf=3.25342e-3            nkf=0.5554402
+ vaf=47.6877977            br=0.302                  nr=0.9869396
+ tlev=1                    isc=1.970838e-18          nc=1.0205444
+ rc=20*rca                 ikr=4.740015e-3           var=28.292768
+ xti=3                     eg=1.17                   xtb=0
+ tbf1=7.2e-3               tbf2=1.2e-5               tikf1=-5e-3
+ tbr1=1.4e-3               tbr2=-5e-6                tne1=2e-4
+ cje=4.872e-15*cjea        vje=0.6882682             mje=0.359
+ cte=9.05e-4               tvje=1.49e-3              cjc=6.058e-14*cjca
+ vjc=0.585                 mjc=0.35                  ctc=1e-3
+ tvjc=1.40e-3              tlevc=1                   fc=0
+ tnom=25                   rbmod=spice               minr=1e-3
ends npn2_mis
 
 
 
endsection bip
// **********************************
//                                  *
//     3.3V PNP  bipolar            * 
//                                  *
// **********************************

section tt_bip3
parameters isa3=1
parameters bfa3=1
parameters nfa3=1
parameters rba3=1
parameters rea3=1
parameters rca3=1
parameters rbma3=1
parameters cjea3=1
parameters cjca3=1
include "cmn018_assp_v1d2.scs" section=bip3
endsection tt_bip3
 

section ss_bip3
parameters isa3=0.70
parameters bfa3=0.85
parameters nfa3=0.9975
parameters rba3=1.2
parameters rea3=1.2
parameters rca3=1.2
parameters rbma3=1.2
parameters cjea3=1.05
parameters cjca3=1.05
include "cmn018_assp_v1d2.scs" section=bip3
endsection ss_bip3
 

section ff_bip3
parameters isa3=1.30
parameters bfa3=1.15
parameters nfa3=1.0025
parameters rba3=0.8
parameters rea3=0.8
parameters rca3=0.8
parameters rbma3=0.8
parameters cjea3=0.95
parameters cjca3=0.95
include "cmn018_assp_v1d2.scs" section=bip3
endsection ff_bip3
 
 

section bip3
// 
model pnp10_3 bjt type=pnp 
+ bf=2.715*bfa3             nf=1.011*nfa3             is=1.5353e-17*isa3
+ ise=1.5353e-17*isa3       isc=1.5353e-17*isa3       ne=1.2977142
+ rb=33.063401*rba3         irb=1.401332e-3           rbm=1.0965611*rbma3
+ re=1.3979963*rea3         ikf=2.05254e-3            nkf=0.477972
+ vaf=361.145               br=9.0433e-3              nr=0.9908706
+ nc=0.9007513              rc=20.08*rca3             ikr=1.98804e-4
+ var=27.84541              xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-3.912025e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=5.11e-3
+ tbf2=1e-6                 tnf1=-1.0025e-4           tne1=2.00234e-4
+ tvaf1=-5e-3               tbr1=-1.95e-3             tbr2=2.25e-5
+ tnc1=8.022278e-5          tnc2=0                    tnr1=-2.025978e-4
+ tnr2=0                    cje=1.058e-13*cjea3       vje=0.805
+ mje=0.395                 fc=0                      cjc=6.838e-14*cjca3
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.940197e-4           ctc=2.8425e-3
+ tvje=1.57e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
model pnp5_3 bjt type=pnp 
+ bf=2.725*bfa3             nf=1.011*nfa3             is=3.5351e-18*isa3
+ ise=3.5351e-18*isa3       isc=3.5351e-18*isa3       ne=1.3977142
+ rb=54.76734*rba3          irb=1.401332e-3           rbm=1.0965611*rbma3
+ re=1.3979963*rea3         ikf=1.1254e-3             nkf=0.477972
+ vaf=372.731               br=3.5513e-3              nr=0.993881
+ nc=0.98076                rc=20.08*rca3             ikr=1.98804e-4
+ var=22.44541              xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-2.752025e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=5.2e-3
+ tbf2=1.1e-6               tnf1=-1.056025e-4         tne1=2.152336e-4
+ tvaf1=-4e-5               tbr1=-1.01e-3             tbr2=1.3e-5
+ tnc1=1.122277e-4          tnc2=0                    tnr1=-1.026101e-4
+ tnr2=0                    cje=2.765e-14*cjea3       vje=0.805
+ mje=0.395                 fc=0                      cjc=3.965e-14*cjca3
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.940197e-4           ctc=2.8425e-3
+ tvje=1.57e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
// 
model pnp2_3 bjt type=pnp 
+ bf=2.7351*bfa3            nf=1.012*nfa3             is=8.03515e-19*isa3
+ ise=8.03515e-19*isa3      isc=8.03515e-19*isa3      ne=1.2977142
+ rb=102.76734*rba3         irb=1.401332e-3           rbm=1.0965611*rbma3
+ re=1.297997*rea3          ikf=4.02541e-4            nkf=0.427981
+ vaf=126.168               br=1.1153e-3              nr=1.013671
+ nc=0.920748               rc=20.08*rca3             ikr=1.98804e-4
+ var=20.0151               xti=3                     eg=1.17
+ xtb=0                     trb1=1.493714e-3          tirb1=1.375303e-5
+ trm1=1.074565e-5          tre1=1.068665e-4          tikf1=-4.31203e-3
+ tikr1=-3.93e-3            trc1=8e-5                 tbf1=5.85e-3
+ tbf2=3e-6                 tnf1=-1.056025e-4         tne1=2.152336e-4
+ tvaf1=-1e-3               tbr1=-1.5e-3              tbr2=1.65e-5
+ tnc1=1.122198e-4          tnc2=0                    tnr1=-2.425601e-4
+ tnr2=0                    cje=5e-15*cjea3           vje=0.805
+ mje=0.395                 fc=0                      cjc=2.563e-14*cjca3
+ vjc=0.5846489             mjc=0.3883243             tlev=1
+ tlevc=1                   cte=9.940197e-4           ctc=2.8425e-3
+ tvje=1.57e-3              tvjc=2.819e-3             tnom=25
+ rbmod=spice               minr=1e-3
//                                                                            
//   
endsection bip3
// 
 
 
// **************************************************************
//                                                              *
//                  1.8V Std-Vt Junction DIODE MODELS           *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio
parameters is_d=1.0
parameters jsw_d=1.0
parameters n_d=1.000
parameters rs_d=1.0
parameters cj_d=1.00
parameters cjsw_d=1.00
include "cmn018_assp_v1d2.scs" section=dio
endsection tt_dio
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio
parameters is_d=0.7
parameters jsw_d=0.5
parameters n_d=0.9975
parameters rs_d=1.2
parameters cj_d=1.07
parameters cjsw_d=1.07
include "cmn018_assp_v1d2.scs" section=dio
endsection ss_dio
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio
parameters is_d=1.3
parameters jsw_d=2.0
parameters n_d=1.0025
parameters rs_d=0.8
parameters cj_d=0.93
parameters cjsw_d=0.93
include "cmn018_assp_v1d2.scs" section=dio
endsection ff_dio
// 

section dio
// 
// **************************************************************
//                       MODEL OF N+/PW DIODE                   *
// **************************************************************
model ndio diode 
+ is=4.98e-7*is_d           isw=4.12e-13*jsw_d        rs=1.0e-10*rs_d
+ n=1.06*n_d                cj=9.81e-04*cj_d          cjsw=1.185e-10*cjsw_d
+ bv=11.25                  area=3.78e-8              pj=9.59e-4
+ mj=0.359                  mjsw=0.202                vj=0.6882682
+ vjsw=0.32                 trs=1.3e-3                tbv1=-1*-8.8e-4
+ cta=9.05e-4               ctp=8.09e-04              pta=1.49e-3
+ ptp=8.94e-04              ibv=0.03                  tnom=25
+ fc=0                      tlev=1                    tlevc=1
+ xti=3                     eg=1.17                   level=1
+ ns=1.06*n_d               nz=1.06*n_d               imax=1e40
+ minr=1e-10                allow_scaling=yes
 
// **************************************************************
//                       MODEL OF P+/NW DIODE                   *
// **************************************************************
model pdio diode 
+ level=1                   is=1.760e-7*is_d          rs=1.0e-10*rs_d
+ n=1.02*n_d                bv=10.2                   ibv=1e-3
+ isw=2.71e-13*jsw_d        area=3.78e-8              pj=9.59e-4
+ cj=1.12e-3*cj_d           vj=0.860                  mj=0.440
+ cjsw=1.345e-10*cjsw_d     vjsw=0.6                  mjsw=0.338
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-8.8e-4           trs=1.2e-4                tlevc=1
+ cta=9.18e-04              ctp=8.86e-04              pta=1.61e-03
+ ptp=1.25e-03              tnom=25                   fc=0
+ ns=1.02*n_d               nz=1.02*n_d               imax=1e40
+ minr=1e-10                allow_scaling=yes
// **************************************************************
//                       MODEL OF NW/Psub DIODE                 *
// **************************************************************
model nwdio diode 
+ level=1                   is=6.50e-7*is_d           rs=1.0e-10*rs_d
+ n=1.03*n_d                bv=14.75                  ibv=1e-3
+ isw=9.75e-13*jsw_d        area=7.5e-8               pj=1.1e-3
+ cj=1.337566e-4*cj_d       vj=0.5846489              mj=0.3883243
+ cjsw=5.333577e-10*cjsw_d  vjsw=0.5846489            mjsw=0.2345684
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-9.6e-4           trs=1.125e-3              tlevc=1
+ cta=2.8425e-3             ctp=1.5284e-3             pta=2.819e-3
+ ptp=2.819e-3              tnom=25                   fc=0
+ ns=1.03*n_d               nz=1.03*n_d               imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio
// 
// **************************************************************
//                  3.3V Std-Vt Junction DIODE MODELS           *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio3
parameters is_d_3=1.0
parameters jsw_d_3=1.0
parameters n_d_3=1.000
parameters rs_d_3=1.0
parameters cj_d_3=1.00
parameters cjsw_d_3=1.00
include "cmn018_assp_v1d2.scs" section=dio3
endsection tt_dio3
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio3
parameters is_d_3=0.7
parameters jsw_d_3=0.5
parameters n_d_3=0.9975
parameters rs_d_3=1.2
parameters cj_d_3=1.07
parameters cjsw_d_3=1.07
include "cmn018_assp_v1d2.scs" section=dio3
endsection ss_dio3
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio3
parameters is_d_3=1.3
parameters jsw_d_3=2.0
parameters n_d_3=1.0025
parameters rs_d_3=0.8
parameters cj_d_3=0.93
parameters cjsw_d_3=0.93
include "cmn018_assp_v1d2.scs" section=dio3
endsection ff_dio3
// 

section dio3
// **************************************************************
//                       MODEL OF N+/PW DIODE                   *
// **************************************************************
model ndio_3 diode 
+ level=1                   is=3.93e-7*is_d_3         rs=1.0e-10*rs_d_3
+ n=1.0*n_d_3               bv=11.04                  ibv=1e-3
+ isw=3.54e-13*jsw_d_3      area=3.78e-8              pj=9.59e-4
+ cj=8.92e-4*cj_d_3         vj=0.707                  mj=0.325
+ cjsw=1.14e-10*cjsw_d_3    vjsw=0.550                mjsw=0.204
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-8.33e-4          trs=1.62e-3               tlevc=1
+ cta=9.06e-4               ctp=7.7e-4                pta=1.70e-3
+ ptp=1.60e-3               tnom=25                   fc=0
+ ns=1.0*n_d_3              nz=1.0*n_d_3              imax=1e40
+ minr=1e-10                allow_scaling=yes
// **************************************************************
//                       MODEL OF P+/NW DIODE                   *
// **************************************************************
model pdio_3 diode 
+ level=1                   is=1.900e-7*is_d_3        rs=1.0e-10*rs_d_3
+ n=1.0*n_d_3               bv=10.53                  ibv=1e-3
+ isw=5.02e-13*jsw_d_3      area=3.78e-8              pj=9.59e-4
+ cj=1.01e-3*cj_d_3         vj=0.805                  mj=0.395
+ cjsw=1.2e-10*cjsw_d_3     vjsw=0.805                mjsw=0.338
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-8.1e-4           trs=1.2e-4                tlevc=1
+ cta=9.940197e-4           ctp=9.19e-4               pta=1.57e-3
+ ptp=1.57e-3               tnom=25                   fc=0
+ ns=1.0*n_d_3              nz=1.0*n_d_3              imax=1e40
+ minr=1e-10                allow_scaling=yes
// **************************************************************
//                       MODEL OF NW/Psub DIODE                 *
// **************************************************************
model nwdio_3 diode 
+ level=1                   is=6.50e-7*is_d_3         rs=1.0e-10*rs_d_3
+ n=1.03*n_d_3              bv=14.75                  ibv=1e-3
+ isw=9.75e-13*jsw_d_3      area=7.5e-8               pj=1.1e-3
+ cj=1.337566e-4*cj_d_3     vj=0.5846489              mj=0.3883243
+ cjsw=5.333577e-10*cjsw_d_3                          vjsw=0.5846489
+ mjsw=0.2345684            tlev=1                    eg=1.17
+ xti=3                     tbv1=-1*-9.6e-4           trs=1.125e-3
+ tlevc=1                   cta=2.8425e-3             ctp=1.5284e-3
+ pta=2.819e-3              ptp=2.819e-3              tnom=25
+ fc=0                      ns=1.03*n_d_3             nz=1.03*n_d_3
+ imax=1e40                 minr=1e-10                allow_scaling=yes
// **************************************************************
//                       MODEL OF ESD DIODE                     *
// **************************************************************
model endio_3 diode 
+ level=1                   cj=1.416999e-3*cj_d_3     vj=0.6798575
+ mj=0.3357974              tnom=25                   fc=0
+ ns=1                      nz=1                      imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio3
// 
// **************************************************************
//                                                              *
//              1.8V Med-Vt Junction DIODE MODELS               *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_m
parameters is_d_m=1.0
parameters jsw_d_m=1.0
parameters n_d_m=1.000
parameters rs_d_m=1.0
parameters cj_d_m=1.00
parameters cjsw_d_m=1.00
include "cmn018_assp_v1d2.scs" section=dio_m
endsection tt_dio_m
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_m
parameters is_d_m=0.7
parameters jsw_d_m=0.5
parameters n_d_m=0.9975
parameters rs_d_m=1.2
parameters cj_d_m=1.07
parameters cjsw_d_m=1.07
include "cmn018_assp_v1d2.scs" section=dio_m
endsection ss_dio_m
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio_m
parameters is_d_m=1.3
parameters jsw_d_m=2.0
parameters n_d_m=1.0025
parameters rs_d_m=0.8
parameters cj_d_m=0.93
parameters cjsw_d_m=0.93
include "cmn018_assp_v1d2.scs" section=dio_m
endsection ff_dio_m
// 

section dio_m
// 
// **************************************************************
//                       MODEL OF N+/PW DIODE                   *
// **************************************************************
model ndio_m diode 
+ is=2.34e-7*is_d_m         isw=7.68e-13*jsw_d_m      rs=1.0e-10*rs_d_m
+ n=1.005*n_d_m             cj=9.13e-04*cj_d_m        cjsw=1.04e-10*cjsw_d_m
+ bv=11.3                   area=3.78e-8              pj=9.59e-4
+ mj=0.333                  mjsw=0.146                vj=0.6882682
+ vjsw=0.290                trs=1.3e-3                tbv1=-1*-9.3e-4
+ cta=9.13e-4               ctp=7.65e-04              pta=1.49e-03
+ ptp=1.00e-03              ibv=0.03                  tnom=25
+ fc=0                      tlev=1                    tlevc=1
+ xti=3                     eg=1.17                   level=1
+ ns=1.005*n_d_m            nz=1.005*n_d_m            imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
// **************************************************************
//                       MODEL OF P+/NW DIODE                   *
// **************************************************************
model pdio_m diode 
+ level=1                   is=1.48e-7*is_d_m         rs=1.0e-10*rs_d_m
+ n=1.005*n_d_m             bv=11.1                   ibv=1e-3
+ isw=4.06e-13*jsw_d_m      area=3.78e-8              pj=9.59e-4
+ cj=1.05e-3*cj_d_m         vj=0.886                  mj=0.440
+ cjsw=1.26e-10*cjsw_d_m    vjsw=0.600                mjsw=0.338
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-8.8e-4           trs=1.2e-4                tlevc=1
+ cta=9.18e-04              ctp=8.86e-04              pta=1.61e-03
+ ptp=1.25e-03              tnom=25                   fc=0
+ ns=1.005*n_d_m            nz=1.005*n_d_m            imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio_m
// 
// **************************************************************
//                                                              *
//                  3.3V Med-Vt Junction DIODE MODELS           *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_3m
parameters is_d_3m=1.0
parameters jsw_d_3m=1.0
parameters n_d_3m=1.000
parameters rs_d_3m=1.0
parameters cj_d_3m=1.00
parameters cjsw_d_3m=1.00
include "cmn018_assp_v1d2.scs" section=dio_3m
endsection tt_dio_3m
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_3m
parameters is_d_3m=0.7
parameters jsw_d_3m=0.5
parameters n_d_3m=0.9975
parameters rs_d_3m=1.2
parameters cj_d_3m=1.07
parameters cjsw_d_3m=1.07
include "cmn018_assp_v1d2.scs" section=dio_3m
endsection ss_dio_3m
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio_3m
parameters is_d_3m=1.3
parameters jsw_d_3m=2.0
parameters n_d_3m=1.0025
parameters rs_d_3m=0.8
parameters cj_d_3m=0.93
parameters cjsw_d_3m=0.93
include "cmn018_assp_v1d2.scs" section=dio_3m
endsection ff_dio_3m
// 

section dio_3m
// 
// **************************************************************
//                       MODEL OF N+/PW DIODE                   *
// **************************************************************
 
model ndio_3m diode 
+ level=1                   is=3.93e-7*is_d_3m        rs=1.0e-10*rs_d_3m
+ n=1.0*n_d_3m              bv=11.04                  ibv=1e-3
+ isw=3.54e-13*jsw_d_3m     area=3.78e-8              pj=9.59e-4
+ cj=8.72e-4*cj_d_3m        vj=0.707                  mj=0.325
+ cjsw=1.22e-10*cjsw_d_3m   vjsw=0.630                mjsw=0.204
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-8.33e-4          trs=1.62e-3               tlevc=1
+ cta=9.20e-4               ctp=7.69e-4               pta=1.70e-3
+ ptp=1.75e-3               tnom=25                   fc=0
+ ns=1.0*n_d_3m             nz=1.0*n_d_3m             imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio_3m
// 
// **************************************************************
//                                                              *
//              DNW Junction DIODE MODELS                       *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_dnw
parameters is_d_dnw=1.0
parameters jsw_d_dnw=1.0
parameters n_d_dnw=1.000
parameters rs_d_dnw=1.0
parameters cj_d_dnw=1.00
parameters cjsw_d_dnw=1.00
include "cmn018_assp_v1d2.scs" section=dio_dnw
endsection tt_dio_dnw
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_dnw
parameters is_d_dnw=0.7
parameters jsw_d_dnw=0.5
parameters n_d_dnw=0.9975
parameters rs_d_dnw=1.2
parameters cj_d_dnw=1.07
parameters cjsw_d_dnw=1.07
include "cmn018_assp_v1d2.scs" section=dio_dnw
endsection ss_dio_dnw
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio_dnw
parameters is_d_dnw=1.3
parameters jsw_d_dnw=2.0
parameters n_d_dnw=1.0025
parameters rs_d_dnw=0.8
parameters cj_d_dnw=0.93
parameters cjsw_d_dnw=0.93
include "cmn018_assp_v1d2.scs" section=dio_dnw
endsection ff_dio_dnw
 

section dio_dnw
// 
// **************************************************************
//                    MODEL OF DNW/PSUB DIODE                   *
// **************************************************************
model dnwpsub diode 
+ level=1                   is=1.40e-6*is_d_dnw       rs=1.0e-10*rs_d_dnw
+ n=1.03*n_d_dnw            bv=14.70                  ibv=1e-3
+ isw=1.10e-12*jsw_d_dnw    area=4.0044e-8            pj=8.48e-4
+ cj=1.40e-4*cj_d_dnw       vj=0.8                    mj=0.490
+ cjsw=1.12e-9*cjsw_d_dnw   vjsw=0.8                  mjsw=0.35
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-9.40e-4          trs=3.35e-3               tlevc=1
+ cta=2.25e-3               ctp=1.60e-3               pta=2.80e-3
+ ptp=2.80e-3               tnom=25                   fc=0
+ ns=1.03*n_d_dnw           nz=1.03*n_d_dnw           imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
// **************************************************************
//                     MODEL OF PW/DNW DIODE                    *
// **************************************************************
// 
model pwdnw diode 
+ level=1                   is=1.20e-6*is_d_dnw       rs=1.0e-10*rs_d_dnw
+ n=1.03*n_d_dnw            bv=14.50                  ibv=1e-3
+ isw=1.0e-12*jsw_d_dnw     area=4.0044e-8            pj=8.48e-4
+ cj=6.80e-4*cj_d_dnw       vj=0.585                  mj=0.350
+ cjsw=5.33e-10*cjsw_d_dnw  vjsw=0.585                mjsw=0.235
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-1.10e-3          trs=3.44e-3               tlevc=1
+ cta=1.0e-3                ctp=1.53e-3               pta=1.4e-3
+ ptp=2.82e-3               tnom=25                   fc=0
+ ns=1.03*n_d_dnw           nz=1.03*n_d_dnw           imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio_dnw
 
 
// **************************************************************
//                                                              *
//                2T Resistor model                              *
//                                                              *
// **************************************************************
// **************************     COMMON STATISTICAL LIBRARY      ***************************

section stat_res
parameters random1_res=0
parameters random2_res=0
parameters random3_res=0
parameters random4_res=0
parameters par1_res=random1_res
parameters par2_res=random2_res
parameters par3_res=random3_res
parameters par4_res=random4_res

statistics {
    process {
        vary random1_res dist=gauss std=1/1
        vary random2_res dist=gauss std=1/1
        vary random3_res dist=gauss std=1/1
        vary random4_res dist=gauss std=1/1
        }
    }
endsection stat_res
 
 

section stat_disres
parameters random1_disres=0
parameters random2_disres=0
parameters random3_disres=0
parameters random4_disres=0
parameters par1_disres=random1_disres
parameters par2_disres=random2_disres
parameters par3_disres=random3_disres
parameters par4_disres=random4_disres

statistics {
    process {
        vary random1_disres dist=gauss std=1/1
        vary random2_disres dist=gauss std=1/1
        vary random3_disres dist=gauss std=1/1
        vary random4_disres dist=gauss std=1/1
        }
    }
endsection stat_disres
 
// *************************** Typical corner of resistor ***********************************

section tt_res
include "cmn018_assp_v1d2.scs" section=setup_res
parameters par_res=0
parameters r_rnod=6.82
parameters r_rnodw=6.82
parameters r_rpod=7.76
parameters r_rpodw=7.76
parameters r_rnwod=440
parameters r_rnwsti=927
parameters r_rnpo1=7.89
parameters r_rnpo1w=7.89
parameters r_rppo1=7.9
parameters r_rppo1w=7.9
parameters r_rm1=0.078
parameters r_rm2=0.078
parameters r_rm3=0.078
parameters r_rm4=0.078
parameters r_rm5=0.078
parameters r_rm6=0.036
parameters r_rnodrpo=61.6
parameters rend_rnodrpo=0.00001366
parameters dxl_rnodrpo=0e-6
parameters dxw_rnodrpo=0e-6
parameters r_rpodrpo=140.6
parameters rend_rpodrpo=0.0000295
parameters dxl_rpodrpo=0e-6
parameters dxw_rpodrpo=0e-6
parameters r_rnpo1rpo=295.3
parameters rend_rnpo1rpo=0.000043
parameters dxl_rnpo1rpo=0e-6
parameters dxw_rnpo1rpo=0e-6
parameters r_rppo1rpo=321.8
parameters rend_rppo1rpo=0.000073
parameters dxl_rppo1rpo=0e-6
parameters dxw_rppo1rpo=0e-6
parameters r_rppolyhri=1037
parameters rend_rppolyhri=0.0000595
parameters dxl_rppolyhri=0e-6
parameters dxw_rppolyhri=0e-6
parameters a1_rppo1rpo=6.75e-23
parameters a1_rppolyhri=1.10e-22
parameters b1_rppo1rpo=-2.875e-23
parameters b1_rppolyhri=-6.99e-23
parameters c1_rppo1rpo=1.00e-22
parameters c1_rppolyhri=2.05e-22
parameters kf_rppo1rpo=a1_rppo1rpo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppo1rpo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppo1rpo
parameters kf_rppolyhri=a1_rppolyhri * (abs(rnoiseflag_res) + rnoiseflag_res) + 
+ b1_rppolyhri * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolyhri
 
include "cmn018_assp_v1d2.scs" section=res
endsection tt_res
// *************************** Slow corner of resistor ***********************************

section ss_res
include "cmn018_assp_v1d2.scs" section=setup_res
parameters par_res=0
parameters r_rnod=6.82 + 2.5
parameters r_rnodw=6.82 + 2.5
parameters r_rpod=7.76 + 3
parameters r_rpodw=7.76 + 3
parameters r_rnwod=440 + 100
parameters r_rnwsti=927 + 132
parameters r_rnpo1=7.89 + 2
parameters r_rnpo1w=7.89 + 2
parameters r_rppo1=7.9 + 2.5
parameters r_rppo1w=7.9 + 2.5
parameters r_rm1=0.078 + 0.023
parameters r_rm2=0.078 + 0.023
parameters r_rm3=0.078 + 0.023
parameters r_rm4=0.078 + 0.023
parameters r_rm5=0.078 + 0.023
parameters r_rm6=0.036 + 0.009
parameters r_rnodrpo=61.6 * 1.0684
parameters rend_rnodrpo=1.366e-05 * 1.202
parameters dxl_rnodrpo=0e-6 - 0e-6
parameters dxw_rnodrpo=0e-6 + 0.0725e-6
parameters r_rpodrpo=140.6 * 1.0696
parameters rend_rpodrpo=2.950e-05 * 1.175
parameters dxl_rpodrpo=0e-6 - 0e-6
parameters dxw_rpodrpo=0e-6 + 0.0743e-6
parameters r_rnpo1rpo=295.3 * 1.0698
parameters rend_rnpo1rpo=4.300e-05 * 1.2105
parameters dxl_rnpo1rpo=0e-6 - 0e-6
parameters dxw_rnpo1rpo=0e-6 + 0.0654e-6
parameters r_rppo1rpo=321.8 * 1.0712
parameters rend_rppo1rpo=7.300e-05 * 1.1705
parameters dxl_rppo1rpo=0e-6 - 0e-6
parameters dxw_rppo1rpo=0e-6 + 0.0629e-6
parameters r_rppolyhri=1037 * 1.0711
parameters rend_rppolyhri=5.950e-05 * 1.4215
parameters dxl_rppolyhri=0e-6 - 0e-6
parameters dxw_rppolyhri=0e-6 + 0.06e-6
parameters a1_rppo1rpo=6.75e-23
parameters a1_rppolyhri=1.10e-22
parameters b1_rppo1rpo=-2.875e-23
parameters b1_rppolyhri=-6.99e-23
parameters c1_rppo1rpo=1.00e-22
parameters c1_rppolyhri=2.05e-22
parameters kf_rppo1rpo=a1_rppo1rpo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppo1rpo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppo1rpo
parameters kf_rppolyhri=a1_rppolyhri * (abs(rnoiseflag_res) + rnoiseflag_res) + 
+ b1_rppolyhri * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolyhri
 
include "cmn018_assp_v1d2.scs" section=res
endsection ss_res
// *************************** Fast corner of resistor ***********************************

section ff_res
include "cmn018_assp_v1d2.scs" section=setup_res
parameters par_res=0
parameters r_rnod=6.82 - 2.5
parameters r_rnodw=6.82 - 2.5
parameters r_rpod=7.76 - 3
parameters r_rpodw=7.76 - 3
parameters r_rnwod=440 - 100
parameters r_rnwsti=927 - 132
parameters r_rnpo1=7.89 - 2
parameters r_rnpo1w=7.89 - 2
parameters r_rppo1=7.9 - 2.5
parameters r_rppo1w=7.9 - 2.5
parameters r_rm1=0.078 - 0.023
parameters r_rm2=0.078 - 0.023
parameters r_rm3=0.078 - 0.023
parameters r_rm4=0.078 - 0.023
parameters r_rm5=0.078 - 0.023
parameters r_rm6=0.036 - 0.009
parameters r_rnodrpo=61.6 * 0.9316
parameters rend_rnodrpo=1.366e-05 * 0.798
parameters dxl_rnodrpo=0e-6 + 0.045e-6
parameters dxw_rnodrpo=0e-6 - 0.0955e-6
parameters r_rpodrpo=140.6 * 0.9304
parameters rend_rpodrpo=2.950e-05 * 0.825
parameters dxl_rpodrpo=0e-6 + 0.0575e-6
parameters dxw_rpodrpo=0e-6 - 0.092e-6
parameters r_rnpo1rpo=295.3 * 0.9302
parameters rend_rnpo1rpo=4.300e-05 * 0.7895
parameters dxl_rnpo1rpo=0e-6 + 0.029e-6
parameters dxw_rnpo1rpo=0e-6 - 0.0855e-6
parameters r_rppo1rpo=321.8 * 0.9288
parameters rend_rppo1rpo=7.300e-05 * 0.8295
parameters dxl_rppo1rpo=0e-6 + 0.0265e-6
parameters dxw_rppo1rpo=0e-6 - 0.084e-6
parameters r_rppolyhri=1037 * 0.9289
parameters rend_rppolyhri=5.950e-05 * 0.5785
parameters dxl_rppolyhri=0e-6 + 0.0184e-6
parameters dxw_rppolyhri=0e-6 - 0.084e-6
parameters a1_rppo1rpo=6.75e-23
parameters a1_rppolyhri=1.10e-22
parameters b1_rppo1rpo=-2.875e-23
parameters b1_rppolyhri=-6.99e-23
parameters c1_rppo1rpo=1.00e-22
parameters c1_rppolyhri=2.05e-22
parameters kf_rppo1rpo=a1_rppo1rpo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppo1rpo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppo1rpo
parameters kf_rppolyhri=a1_rppolyhri * (abs(rnoiseflag_res) + rnoiseflag_res) + 
+ b1_rppolyhri * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolyhri
 
include "cmn018_assp_v1d2.scs" section=res
endsection ff_res
// 

section mc_res
include "cmn018_assp_v1d2.scs" section=setup_res
parameters par_res=0
parameters a1_res_nw=par1_res * 1.4142 / 3
parameters a1_res_rpo=par2_res * 4.3687 / 3.1
parameters a2_res_rpo=par3_res * 0.95606 / 3.1
parameters a1_res_sal=par4_res * 2.8284 / 2.9
parameters r_rnwod=440 + (70.711) * a1_res_nw
parameters r_rnwsti=927 + (93.338) * a1_res_nw
parameters r_rnodrpo=61.6 + (0.95463) * a1_res_rpo + (0.62698) * a2_res_rpo
parameters rend_rnodrpo=0.00001366 + (6.2518e-007) * a1_res_rpo + (4.106e-007) * 
+ a2_res_rpo
parameters dxl_rnodrpo=0e-6 + ( - 5.5209e-009) * a1_res_rpo + (1.0101e-008) * a2_res_rpo
parameters dxw_rnodrpo=0e-6 + (1.9248e-008) * a1_res_rpo + (5.6258e-009) * a2_res_rpo
parameters r_rpodrpo=140.6 + (2.2172) * a1_res_rpo + (1.4562) * a2_res_rpo
parameters rend_rpodrpo=0.0000295 + (1.1697e-006) * a1_res_rpo + (7.6822e-007) * 
+ a2_res_rpo
parameters dxl_rpodrpo=0e-6 + ( - 7.0544e-009) * a1_res_rpo + (1.2907e-008) * a2_res_rpo
parameters dxw_rpodrpo=0e-6 + (1.9006e-008) * a1_res_rpo + (7.0833e-009) * a2_res_rpo
parameters r_rnpo1rpo=295.3 + (4.6701) * a1_res_rpo + (3.0672) * a2_res_rpo
parameters rend_rnpo1rpo=0.000043 + (2.0508e-006) * a1_res_rpo + (1.3469e-006) * 
+ a2_res_rpo
parameters dxl_rnpo1rpo=0e-6 + ( - 3.5579e-009) * a1_res_rpo + (6.5096e-009) * a2_res_rpo
parameters dxw_rnpo1rpo=0e-6 + (1.7284e-008) * a1_res_rpo + (5.2202e-009) * a2_res_rpo
parameters r_rppo1rpo=321.8 + (5.1912) * a1_res_rpo + (3.4095) * a2_res_rpo
parameters rend_rppo1rpo=0.000073 + (2.82e-006) * a1_res_rpo + (1.8521e-006) * a2_res_rpo
parameters dxl_rppo1rpo=0e-6 + ( - 3.2512e-009) * a1_res_rpo + (5.9484e-009) * a2_res_rpo
parameters dxw_rppo1rpo=0e-6 + (1.684e-008) * a1_res_rpo + (4.6237e-009) * a2_res_rpo
parameters r_rppolyhri=1037 + (16.705) * a1_res_rpo + (10.971) * a2_res_rpo
parameters rend_rppolyhri=0.0000595 + (5.6822e-006) * a1_res_rpo + (3.732e-006) 
+ * a2_res_rpo
parameters dxl_rppolyhri=0e-6 + ( - 2.2574e-009) * a1_res_rpo + (4.1302e-009) * 
+ a2_res_rpo
parameters dxw_rppolyhri=0e-6 + (1.6539e-008) * a1_res_rpo + (3.5412e-009) * a2_res_rpo
parameters r_rnod=6.82 + (0.88388) * a1_res_sal
parameters r_rnodw=6.82 + (0.88388) * a1_res_sal
parameters r_rpod=7.76 + (1.0607) * a1_res_sal
parameters r_rpodw=7.76 + (1.0607) * a1_res_sal
parameters r_rnpo1=7.89 + (0.70711) * a1_res_sal
parameters r_rnpo1w=7.89 + (0.70711) * a1_res_sal
parameters r_rppo1=7.9 + (0.88388) * a1_res_sal
parameters r_rppo1w=7.9 + (0.88388) * a1_res_sal
parameters a1_rppo1rpo=6.75e-23
parameters a1_rppolyhri=1.10e-22
parameters b1_rppo1rpo=-2.875e-23
parameters b1_rppolyhri=-6.99e-23
parameters c1_rppo1rpo=1.00e-22
parameters c1_rppolyhri=2.05e-22
parameters kf_rppo1rpo=a1_rppo1rpo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppo1rpo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppo1rpo
parameters kf_rppolyhri=a1_rppolyhri * (abs(rnoiseflag_res) + rnoiseflag_res) + 
+ b1_rppolyhri * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolyhri
parameters r_rm1=0.078
parameters r_rm2=0.078
parameters r_rm3=0.078
parameters r_rm4=0.078
parameters r_rm5=0.078
parameters r_rm6=0.036
 
include "cmn018_assp_v1d2.scs" section=res
endsection mc_res
 

section res
// ************************************
//        2T Resister model           *
// ************************************
// *************************** N+ OD w/i silicide W>2um resistor model ***********************************
subckt rnod ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00822 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnod * (1 + factmis) dw=-0.0765u ptc1=3.35e-3 ptc2=4.31e-7 
+ pvc1=7.56e-5 pvc2=1.24e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnod
 
// *************************** N+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rnodw ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00822 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnodw * (1 + factmis) dw=-0.0765u ptc1=3.35e-3 ptc2=4.31e-7 
+ pvc1=7.56e-5 pvc2=1.24e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnodw
 
// *************************** P+ OD w/i silicide W>2um ***********************************
subckt rpod ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01604 * geo_fac * par_res 
+ * mismatchflag rsh=r_rpod * (1 + factmis) dw=-0.08u ptc1=3.44e-3 ptc2=5.02e-7 
+ pvc1=-2.51e-4 pvc2=1.03e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rpod
 
// *************************** P+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rpodw ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01604 * geo_fac * par_res 
+ * mismatchflag rsh=r_rpodw * (1 + factmis) dw=-0.08u ptc1=3.44e-3 ptc2=5.02e-7 
+ pvc1=-2.51e-4 pvc2=1.03e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rpodw
 
// *************************** NW diff(under OD) ***********************************
subckt rnwod ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rnwod dw=0.141u ptc1=3.68e-3 ptc2=9.54e-6 
+ pvc1=2.77e-3 pvc2=2.49e-4 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnwod
// *************************** NW diff(under STI) ***********************************
subckt rnwsti ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rnwsti dw=0.182u ptc1=2.97e-3 ptc2=1.10e-5 
+ pvc1=8.06e-3 pvc2=-3.32e-4 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnwsti
// *************************** N+ Poly w/i silicide W>2um ***********************************
subckt rnpo1 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00941 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnpo1 * (1 + factmis) dw=-0.057u ptc1=2.92e-3 ptc2=2.66e-7 
+ pvc1=1.35e-3 pvc2=7.15e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnpo1
 
// *************************** N+ Poly w/i silicide 0.18um<W<2um ***********************************
subckt rnpo1w ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00941 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnpo1w * (1 + factmis) dw=-0.057u ptc1=2.92e-3 ptc2=2.66e-7 
+ pvc1=1.35e-3 pvc2=7.15e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnpo1w
 
// *************************** P+ Poly w/i silicide W>2um ***********************************
subckt rppo1 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01320 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppo1 * (1 + factmis) dw=-0.025u ptc1=2.88e-3 ptc2=5.01e-7 
+ pvc1=-7.89e-4 pvc2=6.19e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rppo1
 
// *************************** P+ Poly w/i silicide 0.18um<W<2um ***********************************
subckt rppo1w ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01320 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppo1w * (1 + factmis) dw=-0.025u ptc1=2.88e-3 ptc2=5.01e-7 
+ pvc1=-7.89e-4 pvc2=6.19e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rppo1w
 
// *************************** Metal 1 with W/S=0.23/0.23 ***********************************
subckt rm1 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm1 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm1
// *************************** Metal 2 with W/S=0.28/0.28 ***********************************
subckt rm2 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm2 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm2
// *************************** Metal 3 with W/S=0.28/0.28 ***********************************
subckt rm3 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm3 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm3
// *************************** Metal 4 with W/S=0.28/0.28 ***********************************
subckt rm4 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm4 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm4
// *************************** Metal 5 with W/S=0.28/0.28 ***********************************
subckt rm5 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm5 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm5
// *************************** Metal 6 with W/S=0.44/0.46 ***********************************
subckt rm6 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm6 dw=0.04u ptc1=3.60e-3 ptc2=-1.16e-7 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm6
// *************************** N+ OD w/o silicide 2um<=W ***********************************
subckt rnodrpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.03120 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnodrpo * (1 + factmis) rend0=rend_rnodrpo * (1 + factmis) 
+ dl=0.000e+00 + dxl_rnodrpo dw= - 9.770e-08 + dxw_rnodrpo pt=temp pvce1=0.0189 
+ pvce2=3.92 pvce3=0.182 ptce1=7.691e-04 ptce2=-1.678e-06 pvcp1=-0.299 pvcp2=-0.00000764 
+ pvcp3=2.449 ptcp1=1.478e-03 ptcp2=5.250e-07 tface=1.0 + ptce1 * (pt - 25.0) + 
+ ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt 
+ - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) resistor r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rnodrpo
 
// *************************** N+ Poly w/o silicide 2um<W ***********************************
subckt rnpo1rpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.03056 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnpo1rpo * (1 + factmis) rend0=rend_rnpo1rpo * (1 + factmis) 
+ dl=0.000e+00 + dxl_rnpo1rpo dw=7.100e-08 + dxw_rnpo1rpo pt=temp pvce1=0.5 pvce2=-9.5 
+ pvce3=1.432 ptce1=-1.584e-03 ptce2=-3.950e-07 pvcp1=-0.117 pvcp2=0.0000041 pvcp3=-1.88 
+ ptcp1=-1.506e-03 ptcp2=2.679e-06 tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt 
+ - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * 
+ (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) resistor r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rnpo1rpo
 
// *************************** P+ OD w/o silicide 2um<=W ***********************************
subckt rpodrpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.03708 * geo_fac * par_res 
+ * mismatchflag rsh=r_rpodrpo * (1 + factmis) rend0=rend_rpodrpo * (1 + factmis) 
+ dl=0.000e+00 + dxl_rpodrpo dw= - 7.850e-08 + dxw_rpodrpo pt=temp pvce1=0.3 pvce2=-3.6 
+ pvce3=0.01 ptce1=-1.550e-03 ptce2=1.100e-06 pvcp1=-6.968 pvcp2=-0.0000002037 pvcp3=2.1 
+ ptcp1=1.383e-03 ptcp2=8.632e-07 tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt 
+ - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * 
+ (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) resistor r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rpodrpo
 
// *************************** P+ Poly w/o silicide 2um<W ***********************************
subckt rppo1rpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01146 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppo1rpo * (1 + factmis) rend0=rend_rppo1rpo * (1 + factmis) 
+ dl=0.000e+00 + dxl_rppo1rpo dw=3.000e-08 + dxw_rppo1rpo pt=temp pvce1=-0.35 
+ pvce2=13.5 pvce3=-2.5 ptce1=-2.086e-03 ptce2=1.175e-06 pvcp1=-0.0097 pvcp2=0.0000055 
+ pvcp3=-1.3 ptcp1=-2.380e-04 ptcp2=8.850e-07 tface=1.0 + ptce1 * (pt - 25.0) + 
+ ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt 
+ - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) rppoly r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(V(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
model rppoly resistor 
+ l=(l * factor - dl) / 1   w=mf * (w * factor - dw)
+ kf=kf_rppo1rpo            af=2                      fexp=0.98
+ wdexp=1                      ldexp=1                      
ends rppo1rpo
 
// *************************** P- Poly w/o silicide 2um<W ***********************************
subckt rppolyhri ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00964 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppolyhri * (1 + factmis) rend0=rend_rppolyhri * (1 + factmis) 
+ dl= - 1.900e-09 + dxl_rppolyhri dw=4.161e-08 + dxw_rppolyhri pt=temp pvce1=-0.2909 
+ pvce2=-33.02 pvce3=0.8339 ptce1=-7.700e-04 ptce2=1.294e-07 pvcp1=-0.0364 pvcp2=0.0000045 
+ pvcp3=-1.85 ptcp1=-9.200e-04 ptcp2=1.750e-06 tface=1.0 + ptce1 * (pt - 25.0) + 
+ ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt 
+ - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) rppoly r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(V(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
model rppoly resistor 
+ l=(l * factor - dl) / 1   w=mf * (w * factor - dw)
+ kf=kf_rppolyhri           af=2                      fexp=0.95
+ wdexp=1                      ldexp=1                      
ends rppolyhri
 
endsection res
 
// *************************************************************************
// 
//    3T RESISTANCE MODEL
// 
// *************************************************************************
// *************************** Typical corner of resistor ***********************************

section tt_disres
include "cmn018_assp_v1d2.scs" section=setup_disres
parameters par_res_dis=0
parameters r_rnod_dis=6.82
parameters r_rnodw_dis=6.82
parameters r_rpod_dis=7.76
parameters r_rpodw_dis=7.76
parameters r_rnwod_dis=440
parameters r_rnwsti_dis=927
parameters r_rnpo1_dis=7.89
parameters r_rnpo1w_dis=7.89
parameters r_rppo1_dis=7.9
parameters r_rppo1w_dis=7.9
parameters r_rnodrpo_dis=61.6
parameters rend_rnodrpo_dis=0.00001366
parameters dxl_rnodrpo_dis=0e-6
parameters dxw_rnodrpo_dis=0e-6
parameters r_rpodrpo_dis=140.6
parameters rend_rpodrpo_dis=0.0000295
parameters dxl_rpodrpo_dis=0e-6
parameters dxw_rpodrpo_dis=0e-6
parameters r_rnpo1rpo_dis=295.3
parameters rend_rnpo1rpo_dis=0.000043
parameters dxl_rnpo1rpo_dis=0e-6
parameters dxw_rnpo1rpo_dis=0e-6
parameters r_rppo1rpo_dis=321.8
parameters rend_rppo1rpo_dis=0.000073
parameters dxl_rppo1rpo_dis=0e-6
parameters dxw_rppo1rpo_dis=0e-6
parameters r_rppolyhri_dis=1037
parameters rend_rppolyhri_dis=0.0000595
parameters dxl_rppolyhri_dis=0e-6
parameters dxw_rppolyhri_dis=0e-6
parameters a1_rppo1rpo_dis=6.75e-23
parameters a1_rppolyhri_dis=1.10e-22
parameters b1_rppo1rpo_dis=-2.875e-23
parameters b1_rppolyhri_dis=-6.99e-23
parameters c1_rppo1rpo_dis=1.00e-22
parameters c1_rppolyhri_dis=2.05e-22
parameters kf_rppo1rpo_dis=a1_rppo1rpo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppo1rpo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppo1rpo_dis
parameters kf_rppolyhri_dis=a1_rppolyhri_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppolyhri_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppolyhri_dis
 
include "cmn018_assp_v1d2.scs" section=disres
endsection tt_disres
// *************************** Slow corner of resistor ***********************************

section ss_disres
include "cmn018_assp_v1d2.scs" section=setup_disres
parameters par_res_dis=0
parameters r_rnod_dis=6.82 + 2.5
parameters r_rnodw_dis=6.82 + 2.5
parameters r_rpod_dis=7.76 + 3
parameters r_rpodw_dis=7.76 + 3
parameters r_rnwod_dis=440 + 100
parameters r_rnwsti_dis=927 + 132
parameters r_rnpo1_dis=7.89 + 2
parameters r_rnpo1w_dis=7.89 + 2
parameters r_rppo1_dis=7.9 + 2.5
parameters r_rppo1w_dis=7.9 + 2.5
parameters r_rnodrpo_dis=61.6 * 1.0684
parameters rend_rnodrpo_dis=1.366e-05 * 1.202
parameters dxl_rnodrpo_dis=0e-6 - 0e-6
parameters dxw_rnodrpo_dis=0e-6 + 0.0725e-6
parameters r_rpodrpo_dis=140.6 * 1.0696
parameters rend_rpodrpo_dis=2.950e-05 * 1.175
parameters dxl_rpodrpo_dis=0e-6 - 0e-6
parameters dxw_rpodrpo_dis=0e-6 + 0.0743e-6
parameters r_rnpo1rpo_dis=295.3 * 1.0698
parameters rend_rnpo1rpo_dis=4.300e-05 * 1.2105
parameters dxl_rnpo1rpo_dis=0e-6 - 0e-6
parameters dxw_rnpo1rpo_dis=0e-6 + 0.0654e-6
parameters r_rppo1rpo_dis=321.8 * 1.0712
parameters rend_rppo1rpo_dis=7.300e-05 * 1.1705
parameters dxl_rppo1rpo_dis=0e-6 - 0e-6
parameters dxw_rppo1rpo_dis=0e-6 + 0.0629e-6
parameters r_rppolyhri_dis=1037 * 1.0711
parameters rend_rppolyhri_dis=5.950e-05 * 1.4215
parameters dxl_rppolyhri_dis=0e-6 - 0e-6
parameters dxw_rppolyhri_dis=0e-6 + 0.06e-6
parameters a1_rppo1rpo_dis=6.75e-23
parameters a1_rppolyhri_dis=1.10e-22
parameters b1_rppo1rpo_dis=-2.875e-23
parameters b1_rppolyhri_dis=-6.99e-23
parameters c1_rppo1rpo_dis=1.00e-22
parameters c1_rppolyhri_dis=2.05e-22
parameters kf_rppo1rpo_dis=a1_rppo1rpo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppo1rpo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppo1rpo_dis
parameters kf_rppolyhri_dis=a1_rppolyhri_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppolyhri_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppolyhri_dis
 
include "cmn018_assp_v1d2.scs" section=disres
endsection ss_disres
// *************************** Fast corner of resistor ***********************************

section ff_disres
include "cmn018_assp_v1d2.scs" section=setup_disres
parameters par_res_dis=0
parameters r_rnod_dis=6.82 - 2.5
parameters r_rnodw_dis=6.82 - 2.5
parameters r_rpod_dis=7.76 - 3
parameters r_rpodw_dis=7.76 - 3
parameters r_rnwod_dis=440 - 100
parameters r_rnwsti_dis=927 - 132
parameters r_rnpo1_dis=7.89 - 2
parameters r_rnpo1w_dis=7.89 - 2
parameters r_rppo1_dis=7.9 - 2.5
parameters r_rppo1w_dis=7.9 - 2.5
parameters r_rnodrpo_dis=61.6 * 0.9316
parameters rend_rnodrpo_dis=1.366e-05 * 0.798
parameters dxl_rnodrpo_dis=0e-6 + 0.045e-6
parameters dxw_rnodrpo_dis=0e-6 - 0.0955e-6
parameters r_rpodrpo_dis=140.6 * 0.9304
parameters rend_rpodrpo_dis=2.950e-05 * 0.825
parameters dxl_rpodrpo_dis=0e-6 + 0.0575e-6
parameters dxw_rpodrpo_dis=0e-6 - 0.092e-6
parameters r_rnpo1rpo_dis=295.3 * 0.9302
parameters rend_rnpo1rpo_dis=4.300e-05 * 0.7895
parameters dxl_rnpo1rpo_dis=0e-6 + 0.029e-6
parameters dxw_rnpo1rpo_dis=0e-6 - 0.0855e-6
parameters r_rppo1rpo_dis=321.8 * 0.9288
parameters rend_rppo1rpo_dis=7.300e-05 * 0.8295
parameters dxl_rppo1rpo_dis=0e-6 + 0.0265e-6
parameters dxw_rppo1rpo_dis=0e-6 - 0.084e-6
parameters r_rppolyhri_dis=1037 * 0.9289
parameters rend_rppolyhri_dis=5.950e-05 * 0.5785
parameters dxl_rppolyhri_dis=0e-6 + 0.0184e-6
parameters dxw_rppolyhri_dis=0e-6 - 0.084e-6
parameters a1_rppo1rpo_dis=6.75e-23
parameters a1_rppolyhri_dis=1.10e-22
parameters b1_rppo1rpo_dis=-2.875e-23
parameters b1_rppolyhri_dis=-6.99e-23
parameters c1_rppo1rpo_dis=1.00e-22
parameters c1_rppolyhri_dis=2.05e-22
parameters kf_rppo1rpo_dis=a1_rppo1rpo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppo1rpo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppo1rpo_dis
parameters kf_rppolyhri_dis=a1_rppolyhri_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppolyhri_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppolyhri_dis
 
include "cmn018_assp_v1d2.scs" section=disres
endsection ff_disres
// *************************** MC corner of resistor ***********************************

section mc_disres
include "cmn018_assp_v1d2.scs" section=setup_disres
parameters par_res_dis=0
parameters a1_disres_nw=par1_disres * 1.4142 / 3
parameters a1_disres_rpo=par2_disres * 4.3687 / 3.1
parameters a2_disres_rpo=par3_disres * 0.95606 / 3.1
parameters a1_disres_sal=par4_disres * 2.8284 / 2.9
parameters r_rnwod_dis=440 + (70.711) * a1_disres_nw
parameters r_rnwsti_dis=927 + (93.338) * a1_disres_nw
parameters r_rnodrpo_dis=61.6 + (0.95463) * a1_disres_rpo + (0.62698) * a2_disres_rpo
parameters rend_rnodrpo_dis=0.00001366 + (6.2518e-007) * a1_disres_rpo + (4.106e-007) 
+ * a2_disres_rpo
parameters dxl_rnodrpo_dis=0e-6 + ( - 5.5209e-009) * a1_disres_rpo + (1.0101e-008) 
+ * a2_disres_rpo
parameters dxw_rnodrpo_dis=0e-6 + (1.9248e-008) * a1_disres_rpo + (5.6258e-009) 
+ * a2_disres_rpo
parameters r_rpodrpo_dis=140.6 + (2.2172) * a1_disres_rpo + (1.4562) * a2_disres_rpo
parameters rend_rpodrpo_dis=0.0000295 + (1.1697e-006) * a1_disres_rpo + (7.6822e-007) 
+ * a2_disres_rpo
parameters dxl_rpodrpo_dis=0e-6 + ( - 7.0544e-009) * a1_disres_rpo + (1.2907e-008) 
+ * a2_disres_rpo
parameters dxw_rpodrpo_dis=0e-6 + (1.9006e-008) * a1_disres_rpo + (7.0833e-009) 
+ * a2_disres_rpo
parameters r_rnpo1rpo_dis=295.3 + (4.6701) * a1_disres_rpo + (3.0672) * a2_disres_rpo
parameters rend_rnpo1rpo_dis=0.000043 + (2.0508e-006) * a1_disres_rpo + (1.3469e-006) 
+ * a2_disres_rpo
parameters dxl_rnpo1rpo_dis=0e-6 + ( - 3.5579e-009) * a1_disres_rpo + (6.5096e-009) 
+ * a2_disres_rpo
parameters dxw_rnpo1rpo_dis=0e-6 + (1.7284e-008) * a1_disres_rpo + (5.2202e-009) 
+ * a2_disres_rpo
parameters r_rppo1rpo_dis=321.8 + (5.1912) * a1_disres_rpo + (3.4095) * a2_disres_rpo
parameters rend_rppo1rpo_dis=0.000073 + (2.82e-006) * a1_disres_rpo + (1.8521e-006) 
+ * a2_disres_rpo
parameters dxl_rppo1rpo_dis=0e-6 + ( - 3.2512e-009) * a1_disres_rpo + (5.9484e-009) 
+ * a2_disres_rpo
parameters dxw_rppo1rpo_dis=0e-6 + (1.684e-008) * a1_disres_rpo + (4.6237e-009) 
+ * a2_disres_rpo
parameters r_rppolyhri_dis=1037 + (16.705) * a1_disres_rpo + (10.971) * a2_disres_rpo
parameters rend_rppolyhri_dis=0.0000595 + (5.6822e-006) * a1_disres_rpo + (3.732e-006) 
+ * a2_disres_rpo
parameters dxl_rppolyhri_dis=0e-6 + ( - 2.2574e-009) * a1_disres_rpo + (4.1302e-009) 
+ * a2_disres_rpo
parameters dxw_rppolyhri_dis=0e-6 + (1.6539e-008) * a1_disres_rpo + (3.5412e-009) 
+ * a2_disres_rpo
parameters r_rnod_dis=6.82 + (0.88388) * a1_disres_sal
parameters r_rnodw_dis=6.82 + (0.88388) * a1_disres_sal
parameters r_rpod_dis=7.76 + (1.0607) * a1_disres_sal
parameters r_rpodw_dis=7.76 + (1.0607) * a1_disres_sal
parameters r_rnpo1_dis=7.89 + (0.70711) * a1_disres_sal
parameters r_rnpo1w_dis=7.89 + (0.70711) * a1_disres_sal
parameters r_rppo1_dis=7.9 + (0.88388) * a1_disres_sal
parameters r_rppo1w_dis=7.9 + (0.88388) * a1_disres_sal
parameters a1_rppo1rpo_dis=6.75e-23
parameters a1_rppolyhri_dis=1.10e-22
parameters b1_rppo1rpo_dis=-2.875e-23
parameters b1_rppolyhri_dis=-6.99e-23
parameters c1_rppo1rpo_dis=1.00e-22
parameters c1_rppolyhri_dis=2.05e-22
parameters kf_rppo1rpo_dis=a1_rppo1rpo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppo1rpo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppo1rpo_dis
parameters kf_rppolyhri_dis=a1_rppolyhri_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) 
+ + b1_rppolyhri_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppolyhri_dis
 
include "cmn018_assp_v1d2.scs" section=disres
endsection mc_disres
 

section disres
 
// ************************************
//        3T Resister model           *
// ************************************
// *************************** NW diff(under OD) ***********************************
subckt rnwod_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 rsh=r_rnwod_dis dw=0.141u ptc1=3.68e-3 
+ ptc2=9.54e-6 pvc1=2.77e-3 pvc2=2.49e-4 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) 
+ + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
d1 ( body n2 ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d3 ( body nn ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d4 ( body nx ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d5 ( body n1 ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnwod_m
 
// *************************** NW diff(under STI) ***********************************
subckt rnwsti_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 rsh=r_rnwsti_dis dw=0.182u ptc1=2.97e-3 
+ ptc2=1.10e-5 pvc1=8.06e-3 pvc2=-3.32e-4 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) 
+ + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
d1 ( body n2 ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d3 ( body nn ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d4 ( body nx ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d5 ( body n1 ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnwsti_m
 
// **********************************     N+OD silicide resistor (W>2um)     ***********************************
subckt rnod_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00822 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnod_dis * (1 + factmis) dw=-0.0765u ptc1=3.35e-3 ptc2=4.31e-7 
+ pvc1=7.56e-5 pvc2=1.24e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
d1 ( body n2 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( body nn ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( body nx ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( body n1 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnod_m
 
 
// *************************** N+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rnodw_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00822 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnodw_dis * (1 + factmis) dw=-0.0765u ptc1=3.35e-3 ptc2=4.31e-7 
+ pvc1=7.56e-5 pvc2=1.24e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
d1 ( body n2 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( body nn ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( body nx ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( body n1 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnodw_m
 
// *************************** N+ OD w/o silicide 2um<=W ***********************************
subckt rnodrpo_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.03120 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnodrpo_dis * (1 + factmis) rend0=rend_rnodrpo_dis * (1 + 
+ factmis) dw= - 9.770e-08 + dxw_rnodrpo_dis dl=0 + dxl_rnodrpo_dis pvce1=0.0189 
+ pvce2=3.92 pvce3=0.182 ptce1=7.691e-04 ptce2=-1.678e-06 pvcp1=-0.299 pvcp2=-0.00000764 
+ pvcp3=2.449 ptcp1=1.478e-03 ptcp2=5.250e-07 pt=temp tface=1.0 + ptce1 * (pt 
+ - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) + 
+ ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
d1 ( body ns ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
d2 ( body nm ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d3 ( body nn ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d4 ( body nx ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d5 ( body ne ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
ends rnodrpo_m
 
// *************************** P+ OD w/i silicide W>2um ***********************************
subckt rpod_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01604 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rpod_dis * (1 + factmis) dw=-0.08u ptc1=3.44e-3 ptc2=5.02e-7 
+ pvc1=-2.51e-4 pvc2=1.03e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
d1 ( n2 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( nm body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( nn body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( nx body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( n1 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rpod_m
 
// *************************** P+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rpodw_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01604 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rpodw_dis * (1 + factmis) dw=-0.08u ptc1=3.44e-3 ptc2=5.02e-7 
+ pvc1=-2.51e-4 pvc2=1.03e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
d1 ( n2 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( nm body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( nn body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( nx body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( n1 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rpodw_m
 
// **********************************     P+OD w/o silicide resistor     ***********************************
subckt rpodrpo_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.03708 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rpodrpo_dis * (1 + factmis) rend0=rend_rpodrpo_dis * (1 + 
+ factmis) dw= - 7.850e-08 + dxw_rpodrpo_dis dl=0 + dxl_rpodrpo_dis pvce1=0.3 pvce2=-3.6 
+ pvce3=0.01 ptce1=-1.550e-03 ptce2=1.100e-06 pvcp1=-6.968 pvcp2=-0.0000002037 pvcp3=2.1 
+ ptcp1=1.383e-03 ptcp2=8.632e-07 pt=temp tface=1.0 + ptce1 * (pt - 25.0) + ptce2 
+ * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) 
+ * (pt - 25.0) 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
d1 ( ns body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
d2 ( nm body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d3 ( nn body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d4 ( nx body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d5 ( ne body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
ends rpodrpo_m
 
// *************************** N+Poly w/i silicide W>2um ***********************************
subckt rnpo1_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00941 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnpo1_dis * (1 + factmis) dw=-0.057u ptc1=2.92e-3 ptc2=2.66e-7 
+ pvc1=1.35e-3 pvc2=7.15e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
c1 ( body n2 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
ends rnpo1_dis
 
// *************************** N+Poly w/i silicide 0.18um<W<2um ***********************************
subckt rnpo1w_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00941 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnpo1w_dis * (1 + factmis) dw=-0.057u ptc1=2.92e-3 ptc2=2.66e-7 
+ pvc1=1.35e-3 pvc2=7.15e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
c1 ( body n2 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
ends rnpo1w_dis
 
// *************************** P+Poly w/i silicide W>2um ***********************************
subckt rppo1_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01320 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppo1_dis * (1 + factmis) dw=-0.025u ptc1=2.88e-3 ptc2=5.01e-7 
+ pvc1=-7.89e-4 pvc2=6.19e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
c1 ( body n2 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
ends rppo1_dis
 
// *************************** P+Poly w/i silicide 0.18um<W<2um ***********************************
subckt rppo1w_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01320 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppo1w_dis * (1 + factmis) dw=-0.025u ptc1=2.88e-3 ptc2=5.01e-7 
+ pvc1=-7.89e-4 pvc2=6.19e-3 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) 
r1 ( n2 nm ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r2 ( nm nn ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r3 ( nn nx ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
r4 ( nx n1 ) resistor r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 
+ + pvc1 * abs((v(n2,n1))) + pvc2 * (v(n2,n1)) * (v(n2,n1))) * tfac
c1 ( body n2 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
ends rppo1w_dis
 
// *************************** N+Poly w/o silicide 2um<W ***********************************
subckt rnpo1rpo_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.03056 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnpo1rpo_dis * (1 + factmis) rend0=rend_rnpo1rpo_dis * (1 
+ + factmis) dl=0.000e+00 + dxl_rnpo1rpo_dis dw=7.100e-08 + dxw_rnpo1rpo_dis pt=temp 
+ pvce1=0.5 pvce2=-9.5 pvce3=1.432 ptce1=-1.584e-03 ptce2=-3.950e-07 pvcp1=-0.117 
+ pvcp2=0.0000041 pvcp3=-1.88 ptcp1=-1.506e-03 ptcp2=2.679e-06 tface=1.0 + ptce1 
+ * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) 
+ + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
c1 ( body ns ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c5 ( body ne ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
ends rnpo1rpo_dis
 
// *************************** P+Poly w/o silicide 2um<W ***********************************
subckt rppo1rpo_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01146 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppo1rpo_dis * (1 + factmis) rend0=rend_rppo1rpo_dis * (1 
+ + factmis) dl=0.000e+00 + dxl_rppo1rpo_dis dw=3.000e-08 + dxw_rppo1rpo_dis pt=temp 
+ pvce1=-0.35 pvce2=13.5 pvce3=-2.5 ptce1=-2.086e-03 ptce2=1.175e-06 pvcp1=-0.0097 
+ pvcp2=0.0000055 pvcp3=-1.3 ptcp1=-2.380e-04 ptcp2=8.850e-07 tface=1.0 + ptce1 
+ * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * (pt - 25.0) 
+ + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
c1 ( body ns ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c5 ( body ne ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
model rppoly resistor 
+ l=(lr * factor - dl) / 4                            w=mf * (wr * factor - dw)
+ kf=kf_rppo1rpo_dis        af=2                      fexp=0.98
+ wdexp=1                      ldexp=1                      
ends rppo1rpo_dis
 
// *************************** P- Poly w/o silicide 2um<W ***********************************
subckt rppolyhri_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00964 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppolyhri_dis * (1 + factmis) rend0=rend_rppolyhri_dis * 
+ (1 + factmis) dl= - 1.900e-09 + dxl_rppolyhri_dis dw=4.161e-08 + dxw_rppolyhri_dis 
+ pt=temp pvce1=-0.2909 pvce2=-33.02 pvce3=0.8339 ptce1=-7.700e-04 ptce2=1.294e-07 
+ pvcp1=-0.0364 pvcp2=0.0000045 pvcp3=-1.85 ptcp1=-9.200e-04 ptcp2=1.750e-06 tface=1.0 
+ + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * 
+ (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) rppoly r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(V(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
c1 ( body ns ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
c5 ( body ne ) capacitor c=mf * (0.0863e-15 * ((lr * factor + 1.08u) * wr * factor 
+ / 5.0) * 1e12 + 2 * 0.0373e-15 * (lr * factor + 1.08u) / 5.0 * 1e6)
model rppoly resistor 
+ l=(lr * factor - dl) * 0.211                        w=mf * (wr * factor - dw)
+ kf=kf_rppolyhri_dis       af=2                      fexp=0.95
+ wdexp=1                      ldexp=1                      
ends rppolyhri_dis
 
endsection disres
 
 
// *******************************************************
// ****** Baseband MOS Varactor Corner Parameters ********
// *******************************************************
 

section tt_bbmvar
parameters cmv_bb_cgmin=1.0
parameters cmv_bb_dcg=1.0
include "cmn018_assp_v1d2.scs" section=bb_mvar
endsection tt_bbmvar
 

section ff_bbmvar
parameters cmv_bb_cgmin=0.92
parameters cmv_bb_dcg=0.9556
include "cmn018_assp_v1d2.scs" section=bb_mvar
endsection ff_bbmvar
 

section ss_bbmvar
parameters cmv_bb_cgmin=1.08
parameters cmv_bb_dcg=1.0444
include "cmn018_assp_v1d2.scs" section=bb_mvar
endsection ss_bbmvar
 

section mc_bbmvar
parameters par1_bbmvar=0
parameters par2_bbmvar=0
parameters a1_bbmvar=0.0267 * par1_bbmvar
parameters a2_bbmvar=0.0148 * par2_bbmvar
parameters cmv_bb_cgmin=1.0 + a1_bbmvar
parameters cmv_bb_dcg=1.0 + a2_bbmvar

statistics {
    process {
        vary par1_bbmvar dist=gauss std=1/1
        vary par2_bbmvar dist=gauss std=1/1
        }
    }
include "cmn018_assp_v1d2.scs" section=bb_mvar
endsection mc_bbmvar
 

section bb_mvar
 
// *************************************************************************
//                                                                         *
//                  1.8V IO NMOS in N-Well varactor MODEL                  *
//                                                                         *
// *************************************************************************
subckt nmoscap ( ng nds ) 
parameters lr=1e-6 wr=1e-6 mr=1 factor=1 area=lr * factor * wr * factor * mr pj=2 
+ * wr * factor * mr dt=temp - 25 cgmin=(3.727e-10 * pj + 2.008e-03 * area) * 
+ (1 + 4.84e-5 * dt + 8.53e-7 * dt * dt) * cmv_bb_cgmin dcg=( - 2.42e-11 * pj + 
+ 3.298e-03 * area) * (1 - 8.303e-5 * dt - 2.889e-7 * dt * dt) * cmv_bb_dcg dvgs= 
+ - 0.08179 - 1.531e-04 * dt vgnorm=0.3939 + 5.273e-04 * dt 
cg ( ng nds ) bsource q=((cgmin+dcg)*v(ng,nds)+vgnorm*dcg*ln(cosh((v(ng,nds)-dvgs)/vgnorm)))
ends nmoscap
 
// *************************************************************************
//                                                                         *
//                  3.3V IO NMOS in N-Well varactor MODEL                  *
//                                                                         *
// *************************************************************************
subckt nmoscap_33 ( ng nds ) 
parameters lr=1e-6 wr=1e-6 mr=1 factor=1 area=lr * factor * wr * factor * mr pj=2 
+ * wr * factor * mr dt=temp - 25 cgmin=(3.334e-10 * pj + 1.549e-03 * area) * 
+ (1 + 3.001e-4 * dt + 6.033e-6 * dt ** 2) * cmv_bb_cgmin dcg=( - 1.655e-11 * pj 
+ + 1.769e-03 * area) * (1 - 2.486e-4 * dt - 2.636e-6 * dt ** 2) * cmv_bb_dcg dvgs= 
+ - 0.2032 + 3.961e-05 * dt vgnorm=0.635 + 1.755e-04 * dt 
cg ( ng nds ) bsource q=((cgmin+dcg)*v(ng,nds)+vgnorm*dcg*ln(cosh((v(ng,nds)-dvgs)/vgnorm)))
ends nmoscap_33
 
endsection bb_mvar
 
 
// *******************************************************************************
// 
//  MIM Capacitor Model
// 
// *******************************************************************************
 

section stat_mim
parameters mimrandom1=0
parameters mimpar1=mimrandom1

statistics {
    process {
        vary mimrandom1 dist=gauss std=1/1
        }
    }
endsection stat_mim
 

section tt_mim
include "cmn018_assp_v1d2.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.0
parameters cm5bb_mimfac=1.0
include "cmn018_assp_v1d2.scs" section=mim
endsection tt_mim
 

section ff_mim
include "cmn018_assp_v1d2.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=0.85
parameters cm5bb_mimfac=0.9538
include "cmn018_assp_v1d2.scs" section=mim
endsection ff_mim
 

section ss_mim
include "cmn018_assp_v1d2.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.15
parameters cm5bb_mimfac=1.052
include "cmn018_assp_v1d2.scs" section=mim
endsection ss_mim
 

section mc_mim
include "cmn018_assp_v1d2.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.0 + 0.05 * mimpar1
parameters cm5bb_mimfac=1.0
include "cmn018_assp_v1d2.scs" section=mim
endsection mc_mim
 
 

section mim
// *************************************************************************************************
//  2) MIM BaseBand CAPACITOR MODEL :
// 
// 
//      ## library files:
//      
//      1. The BB 1.0fF MIM capacitors without Shield are modeled with 2T sub-circuit 
//  'mimcap_1p0_sin'      
// 
//       .subckt mimcap_1p0_sin : Typical model,  
// 
//      2. The BB 1.0fF MIM capacitors without Shield are modeled with 3T sub-circuit 
//  'mimcap_1p0_sin_3t'      
// 
//       .subckt mimcap_1p0_sin_3t : Typical model,  
//       
//      3. The BB 2.0fF MIM capacitors without Shield are modeled with 2T sub-circuit 
//  'mimcap_2p0_sin'      
// 
//       .subckt mimcap_2p0_sin : Typical model,  
// 
//      4. The BB 2.0fF MIM capacitors without Shield are modeled with 3T sub-circuit 
//  'mimcap_2p0_sin_3t'      
// 
//       .subckt mimcap_2p0_sin_3t : Typical model,  
//       
//       
//             Model name                     lt                wt          unit
//                                        low    high       low    high
//             -------------------------------------------------------------------
//             mimcap_1p0_sin              4      30         4      30       um
//             mimcap_1p0_sin_3t           4      30         4      30       um
//             mimcap_2p0_sin              4      30         4      30       um
//             mimcap_2p0_sin_3t           4      30         4      30       um
//             -------------------------------------------------------------------
//             **lt: length dimension of top metal
//             **wt: width dimension of top metal
//             **lt >= wt
//             **lay: metal layer number of stack-up, such as 1P6M, lay=6.
//         The CTM enclosure by CBM with 0.4um/per side is based on the minimum 
//  design rule 
//         for parasitic capacitance pre-simulation in PDK.
//             
// *************************************************************************************************
// *************************** 2 T 1p0 MiM cap ********************************************
subckt mimcap_1p0_sin ( top bottom ) 
parameters lt=10u wt=10u factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 / 
+ sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.0181 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * ((wt * factor * lt * factor * 1e12 * 
+ 1.025) + 2 * (wt * factor + lt * factor) * 1e6 * 0.2425) * 1e-15 * (1 + (temp 
+ - 25) *  - 5.225e-5 + (temp - 25) ** 2 * 1e-8) 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*6.16e-5+1/3*v(top,bottom)**3*-2.05e-5)*cmimbb_mimfac*mf
 
ends mimcap_1p0_sin
 
// *************************** 3 T 1p0 MiM cap ********************************************
subckt mimcap_1p0_sin_3t ( top bottom gnode ) 
parameters lt=10u wt=10u lay=6 factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 
+ / sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.0181 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * ((wt * factor * lt * factor * 1e12 * 
+ 1.025) + 2 * (wt * factor + lt * factor) * 1e6 * 0.2425) * 1e-15 * (1 + (temp 
+ - 25) *  - 5.225e-5 + (temp - 25) ** 2 * 1e-8) cox_para=((lt * factor * 1e6 
+ + 0.8) * (wt * factor * 1e6 + 0.8) * 0.005071 + 2 * ((lt * factor * 1e6 + 0.8) 
+ + (wt * factor * 1e6 + 0.8)) * 0.0112) * 1e-15 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*6.16e-5+1/3*v(top,bottom)**3*-2.05e-5)*cmimbb_mimfac*mf
 
cox ( bottom gnode ) capacitor c=cox_para * ((1 / (15.90757 + (4.14141672) * (lay 
+ - 4))) / 0.041337843) * cm5bb_mimfac * mf
// 
ends mimcap_1p0_sin_3t
 
// *************************** 2 T 2p0 MiM cap ********************************************
subckt mimcap_2p0_sin ( top bottom ) 
parameters lt=10u wt=10u factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 / 
+ sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.0177 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * ((wt * factor * lt * factor * 1e12 * 
+ 1.955) + 2 * (wt * factor + lt * factor) * 1e6 * 0.27) * 1e-15 * (1 + (temp 
+ - 25) *  - 2.94e-5 + (temp - 25) ** 2 * 0e-8) 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*12.8E-5+1/3*v(top,bottom)**3*-5.7E-5)*cmimbb_mimfac*mf
 
ends mimcap_2p0_sin
 
// *************************** 3 T 2p0 MiM cap ********************************************
subckt mimcap_2p0_sin_3t ( top bottom gnode ) 
parameters lt=10u wt=10u lay=6 factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 
+ / sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.0177 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * ((wt * factor * lt * factor * 1e12 * 
+ 1.955) + 2 * (wt * factor + lt * factor) * 1e6 * 0.27) * 1e-15 * (1 + (temp 
+ - 25) *  - 2.94e-5 + (temp - 25) ** 2 * 0e-8) cox_para=((lt * factor * 1e6 + 
+ 0.8) * (wt * factor * 1e6 + 0.8) * 0.005071 + 2 * ((lt * factor * 1e6 + 0.8) + 
+ (wt * factor * 1e6 + 0.8)) * 0.0112) * 1e-15 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*12.8E-5+1/3*v(top,bottom)**3*-5.7E-5)*cmimbb_mimfac*mf
 
cox ( bottom gnode ) capacitor c=cox_para * ((1 / (15.90757 + (4.14141672) * (lay 
+ - 4))) / 0.041337843) * cm5bb_mimfac * mf
// 
ends mimcap_2p0_sin_3t
 
 
endsection mim
 
 
// **********************************************************************
//              	              RTMOM                                   *
// **********************************************************************
// ************ Library of typical corner *******************************

section stat_mom
parameters momrandom=0
parameters mompar=momrandom

statistics {
    process {
        vary momrandom dist=gauss std=1/1
        }
    }
 
endsection stat_mom
 
// ************ Library of typical corner *******************************
 

section tt_rtmom
include "cmn018_assp_v1d2.scs" section=setup_rtmom
parameters rtmom_fac=1
parameters par_mom=0
include "cmn018_assp_v1d2.scs" section=rtmom
endsection tt_rtmom
 
// ************ Library of slow corner **********************************
 

section ss_rtmom
include "cmn018_assp_v1d2.scs" section=setup_rtmom
parameters rtmom_fac=1.25
parameters par_mom=0
include "cmn018_assp_v1d2.scs" section=rtmom
endsection ss_rtmom
 
// ************ Library of fast corner **********************************
 

section ff_rtmom
include "cmn018_assp_v1d2.scs" section=setup_rtmom
parameters rtmom_fac=0.75
parameters par_mom=0
include "cmn018_assp_v1d2.scs" section=rtmom
endsection ff_rtmom
 
// ************ Library of MC corner **********************************
 

section mc_rtmom
include "cmn018_assp_v1d2.scs" section=setup_rtmom
parameters rtmom_fac=1.0 + 0.0625 * mompar
parameters par_mom=0
 
include "cmn018_assp_v1d2.scs" section=rtmom
endsection mc_rtmom
 
// ***********************************************************************
 

section rtmom
// *****************************************************************************************
//                                                                            
//               *
//            018 BB RTMOM                                                    
//               *
//                                                                            
//               *
//            parameter range: nv : 6~288, nh : 6~288                         
//               *
//                             nv and nh should be even fingers               
//               *
//                             w(width):0.28u ~0.32u                          
//               *
//                             s(spacing):0.28u ~0.32u                        
//               *
//                             stm(start metal layer):M1,M2,M3                
//               *
//                             spm(stop metal layer):M3,M4,M5                 
//               *
//                             Total metal is at least 3 layers stacked with ploy 
//  shield   *
//                             mismatchflag : 0 represents no mis-match       
//               *
//                                            1 represents Parallel mis-match 
//               *
//                                                                            
//               *
//                                                                            
//               *
// *****************************************************************************************
subckt crtmom ( a b p ) 
parameters nv=32 nh=32 w=0.28u s=0.28u stm=1 spm=5 factor=1 mf=1 mismatchflag=mismatchflag_rtmom 
+ layno=spm - stm + 1 laym1=int(layno / spm) layodd=int((layno + (stm - 2) * (stm 
+ - 3) * (stm - 4) * (stm - 5) / (24) + (stm - 1) * (stm - 2) * (stm - 4) * (stm 
+ - 5) / (4) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 4) / 24) / 2) - laym1 
+ layeven=int((layno + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) / ( - 6) + 
+ (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / ( - 6)) / 2) edg=((layodd + 5300 
+ / 5300 * laym1) * (nv - 1) * (nh * (w * factor + s * factor) - s * factor) + layeven 
+ * (nh - 1) * (nv * (w * factor + s * factor) - s * factor)) area=nv * nh / 2 * 
+ w * factor * (layno - 1) fri1=(2 * nh * nv * w * factor) * (layno - 1) fri2=((layodd 
+ + laym1) * nv * w * factor + layeven * nh * w * factor) + layeven * (nv * (w * 
+ factor + s * factor) - s * factor + 0.5u) * 2 + layno * 0.28u * 2 + (layodd + 
+ 5300 / 5300 * laym1) * (nh * (w * factor + s * factor) - s * factor) * 2 abm=((nv 
+ * (w * factor + s * factor) - s * factor + (0.28u + 0.5u) * 2) + (nh * (w * factor 
+ + s * factor) - s * factor + 0.5u)) * 0.28u afm=(nv * w * factor * (nh * (w * 
+ factor + s * factor) - s * factor + 0.5u)) / 2 pf=(nh * (w * factor + s * factor) 
+ - s * factor + 0.5u) * (nv) * 2 / 2 + 2 * ((nv * (w * factor + s * factor) - s 
+ * factor + (0.5u + 0.28u) * 2) + (nh * (w * factor + s * factor) - s * factor 
+ + 0.5u + 0.28u)) pfb=((nh * (w * factor + s * factor) - s * factor) + 0.5u + 0.28u) 
+ * 2.7 cc1=0.023964608 / (s * factor * 1e6) - 0.000227392 / (w * factor * 1e6) 
+ - 0.000501253 / (s * factor * 1e6) / (w * factor * 1e6) + 0.008322715 cc2=0.0497 
+ cf=0.015000000 * (s * factor * 1e6) - 0.002500000 * (w * factor * 1e6) + 0.006250000 
+ * (s * factor * 1e6) * (w * factor * 1e6) + 0.001339500 ca=0.000000000 * (s * 
+ factor * 1e6) + 0.040000000 * (w * factor * 1e6) + 0.000000000 * (s * factor * 
+ 1e6) * (w * factor * 1e6) - 0.000100000 ca_p_a=((stm - 2) * (stm - 3) / (1 - 2) 
+ / (1 - 3) * (0.000000000) + (stm - 1) * (stm - 3) / (2 - 1) / (2 - 3) * (0.000000000) 
+ + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.000000000)) ca_p_b=((stm - 2) 
+ * (stm - 3) / (1 - 2) / (1 - 3) * (0.065000000) + (stm - 1) * (stm - 3) / (2 - 
+ 1) / (2 - 3) * (0.017500000) + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.010250000)) 
+ ca_p_c=((stm - 2) * (stm - 3) / (1 - 2) / (1 - 3) * (0.000000000) + (stm - 1) 
+ * (stm - 3) / (2 - 1) / (2 - 3) * (0.000000000) + (stm - 1) * (stm - 2) / (3 - 
+ 1) / (3 - 2) * (0.000000000)) ca_p_d=((stm - 2) * (stm - 3) / (1 - 2) / (1 - 3) 
+ * (0.000100000) + (stm - 1) * (stm - 3) / (2 - 1) / (2 - 3) * (0.000040000) + 
+ (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * ( - 0.000019000)) cf_p_a=((stm - 2) 
+ * (stm - 3) / (1 - 2) / (1 - 3) * (0.031750000) + (stm - 1) * (stm - 3) / (2 - 
+ 1) / (2 - 3) * (0.005750000) + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.002750000)) 
+ cf_p_b=((stm - 2) * (stm - 3) / (1 - 2) / (1 - 3) * (0.006000000) + (stm - 1) 
+ * (stm - 3) / (2 - 1) / (2 - 3) * ( - 0.002500000) + (stm - 1) * (stm - 2) / (3 
+ - 1) / (3 - 2) * ( - 0.002250000)) cf_p_c=((stm - 2) * (stm - 3) / (1 - 2) / (1 
+ - 3) * ( - 0.018750001) + (stm - 1) * (stm - 3) / (2 - 1) / (2 - 3) * (0.006250000) 
+ + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.006250000)) cf_p_d=((stm - 2) 
+ * (stm - 3) / (1 - 2) / (1 - 3) * ( - 0.000779500) + (stm - 1) * (stm - 3) / (2 
+ - 1) / (2 - 3) * (0.001288500) + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.001129500)) 
+ ca_p=(ca_p_a * (s * factor * 1e6) + ca_p_b * (w * factor * 1e6) + ca_p_c * (s 
+ * factor * 1e6) * (w * factor * 1e6) + ca_p_d) cf_p=cf_p_a * (s * factor * 1e6) 
+ + cf_p_b * (w * factor * 1e6) + cf_p_c * (s * factor * 1e6) * (w * factor * 1e6) 
+ + cf_p_d cc_p=0.0451 slope_mis=(0.01611) geo_fac=1 / sqrt(((cc1 * edg * 1e-9 + 
+ cf * 1e-9 * fri1 + ca * 1e-9 * area + cc2 * 1e-9 * fri2) + (ca_p * (abm + afm) 
+ / (w * factor * 1e6) * 1e-3 + cf_p * pf * 1e-9 + cc_p * pfb * 1e-9)) * 1e15 * 
+ mf) factmis=slope_mis * geo_fac * par_mom * mismatchflag 
// 
cab ( a b ) bsource q=(1+factmis)*(cc1*edg*1e-9+cf*1e-9*fri1+ca*1e-9*area+cc2*1e-9*fri2)*(1+(temp-25)*(30.05*1e-6)+(temp-25)*(temp-25)*(-9e-8))*(v(a,b)-1*1e-6*1/2*v(a,b)**2+0.5*1e-6*1/3*v(a,b)**3)*mf*rtmom_fac
cpa ( a p ) bsource q=(1+factmis)*(ca_p*(abm+afm)/(w*factor*1e6)*1e-3+cf_p*pf*1e-9+cc_p*pfb*1e-9)*(1+(temp-25)*(30.05*1e-6)+(temp-25)*(temp-25)*(-9e-8))*(v(a,p)-1*1e-6*1/2*v(a,p)**2+0.5*1e-6*1/3*v(a,p)**3)*mf*rtmom_fac
cpb ( b p ) bsource q=(1+factmis)*(ca_p*(abm+afm)/(w*factor*1e6)*1e-3+cf_p*pf*1e-9+cc_p*pfb*1e-9)*(1+(temp-25)*(30.05*1e-6)+(temp-25)*(temp-25)*(-9e-8))*(v(b,p)-1*1e-6*1/2*v(b,p)**2+0.5*1e-6*1/3*v(b,p)**3)*mf*rtmom_fac
ends crtmom
 
endsection rtmom
 
 
// **********************************************************************
//              	              FMOM                                    *
// **********************************************************************
// ************ Library of typical corner *******************************

section tt_fmom
include "cmn018_assp_v1d2.scs" section=setup_fmom
parameters par_fmom=0
parameters fmom_fac=1
parameters fmom_fac2=1
include "cmn018_assp_v1d2.scs" section=fmom
endsection tt_fmom
 
// ************ Library of slow corner **********************************

section ss_fmom
include "cmn018_assp_v1d2.scs" section=setup_fmom
parameters par_fmom=0
parameters fmom_fac=1.2
parameters fmom_fac2=1.4
include "cmn018_assp_v1d2.scs" section=fmom
endsection ss_fmom
 
// ************ Library of fast corner **********************************

section ff_fmom
include "cmn018_assp_v1d2.scs" section=setup_fmom
parameters par_fmom=0
parameters fmom_fac=0.8
parameters fmom_fac2=0.6
include "cmn018_assp_v1d2.scs" section=fmom
endsection ff_fmom
 
// ************ Library of MC corner **********************************

section mc_fmom
include "cmn018_assp_v1d2.scs" section=setup_fmom
parameters par_fmom=0
parameters a1_mom=mompar * 1.0000e+000 / 3
parameters fmom_fac=1.0000e+000 + (2.0000e-001) * a1_mom
parameters fmom_fac2=1.0000e+000 + (4.0000e-001) * a1_mom
 
include "cmn018_assp_v1d2.scs" section=fmom
endsection mc_fmom
// ******************************************************************************************

section fmom
// ******************************************************************************************
//                                                                            
//                *
// 0.18umBB FMOM                                                              
//     		  *
//                                                                            
//                *
//            parameter range: nr :8~290(should be even fingers)				  *
//                             lr :3u ~ 168u						  *
//                             w(width):0.28u ~ 0.32u				    	  *
//                             s(spacing):0.28u ~ 0.32u					  *
//                             stm(start metal layer):M1,M2,M3                
//       	  *
//                             spm(stop metal layer):M3,M4,M5                 
//     		  *
//                             Total metal is at least 3 layers stacked with ploy 
//  shield    *
//              		     L Bus metal width (with via) : 0.28um (Non scalable)   
//        *		
//              		     Dummy Bus Width = finger width                         
//        *		
//               		     Dummy Bus Space = finger space                        
//         *			
//                             Ftip = 0.5um (Non scalable)          	         
//           *
//                             Distance between DBW and pickup metal : 0.5um (Non 
//  scalable) *
//                             mismatchflag=0 for no mismatch                 
//                *
//                             mismatchflag=1 for parallel                    
//                *
//                                                                            
//                *
// ******************************************************************************************
 
subckt cfmom ( a b p ) 
parameters nr=8 lr=167.5u w=0.32u s=0.32u stm=2 spm=5 mf=1 factor=1 mismatchflag=mismatchflag_fmom 
+ ww=w * 1e6 * factor ss=s * 1e6 * factor ll=lr * 1e6 * factor layno=spm - stm + 
+ 1 lnr=nr * (ww + ss) - ss j1=(stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) * (stm 
+ - 6) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) / (1 - 6) j2=(stm - 1) * (stm - 3) 
+ * (stm - 4) * (stm - 5) * (stm - 6) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) / 
+ (2 - 6) j3=(stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) * (stm - 6) / (3 - 1) 
+ / (3 - 2) / (3 - 4) / (3 - 5) / (3 - 6) tcc1=24.002 * 1e-6 tcc2=0.033 * 1e-6 vcc1=0.6976 
+ * 1e-6 vcc2= - 0.5168 * 1e-6 tfac=1 + tcc1 * (temp - 25) + tcc2 * (temp - 
+ 25) * (temp - 25) wb=0.28 * 1e-6 ftip=0.5 * 1e-6 cfg=((1.58502456697802e-03 
+ / ww + 4.97834615382138e-02 / ss +  - 8.69991468352519e-03 / ww / ss + 0.141092575577826)) 
+ * (0.887) cfg_t=(( - 1.45133875490407e-03 / ww + 0.051901629507603 / ss +  - 1.7164057841426e-03 
+ / ww / ss + 0.058158748650859)) * (0.86) cfg_b=(( - 7.51670687057387e-04 / ww 
+ + 5.19814417344521e-02 / ss +  - 1.45077745025167e-03 / ww / ss + 4.69794855516748e-02)) 
+ * (0.92) cfg_b_m1=((6.65867866332224e-04 / ww + 5.27140572153396e-02 / ss +  - 
+ 1.35294557061935e-03 / ww / ss + 0.021114140335185)) * (1) cfge=(( - 3.58921897506737e-03 
+ / ww + 2.17531337273711e-02 / ss + 2.22078239338076e-04 / ww / ss + 3.39251743618729e-02)) 
+ * (1.03) cfge_t=(( - 2.067472379465e-04 / ww + 1.89594574185258e-02 / ss +  - 
+ 5.90024678651475e-04 / ww / ss + 4.78083405448536e-02)) * (0.59) cfge_b=(( - 4.08481609189726e-03 
+ / ww + 2.07839555057359e-02 / ss + 5.31365394776244e-04 / ww / ss + 3.24968359914656e-02)) 
+ * (1.19) cfge_b_m1=((2.0613984133751e-03 / ww + 2.68051143896327e-02 / ss +  - 
+ 1.14880307083888e-03 / ww / ss + 1.08626496746679e-03)) * (1) cbus=(0.066188) 
+ * (1.52) cbus_t=(0.070721) * (1) cbus_b=(0.062123) * (1.62) cbus_b_m1=(0.052392) 
+ * (1) cfinger=((layno - 2) * cfg + cfg_t + cfg_b * (j2 + j3) + cfg_b_m1 * j1) 
+ / 2 * (nr - 3) * ll cedge=((layno - 2) * cfge + cfge_t + cfge_b * (j2 + j3) + 
+ cfge_b_m1 * j1) * ll * 2 cedge2=((layno - 2) * cbus + cbus_t + cbus_b * (j2 + 
+ j3) + cbus_b_m1 * j1) * nr * ww cp_m1fg=j1 * (7.07541668838077e-02 * ww + 6.21037700315025e-02 
+ * ss + 6.24999341603259e-04 * ww * ss + 1.28949596878795e-03) * 0.988 cp_m2fg=j2 
+ * (1.80585317457402e-02 * ww + 1.73843253965345e-02 * ss +  - 2.97619037915623e-05 
+ * ww * ss + 8.04933863307867e-05) * 1.103 cp_m3fg=j3 * (1.03166466568724e-02 * 
+ ww + 1.00910117360319e-02 * ss + 5.05958000334281e-05 * ww * ss + 3.52388072156329e-05) 
+ * 1.116 cp_m1fge=j1 * (0.135273359618694 * ww + 1.35405398464984e-02 * ss +  - 
+ 0.247736013611283 * ww * ss +  - 2.34920544459968e-03) * 1 cp_m2fge=j2 * (9.96401910145081e-04 
+ * ww +  - 4.1542717932859e-03 * ss +  - 8.39105828027469e-05 * ww * ss + 1.56738096602432e-02) 
+ * 0.881 cp_m3fge=j3 * (6.16953923242438e-03 * ww + 1.87598430851836e-03 * ss + 
+ 8.26070374619411e-03 * ww * ss +  - 8.46620765503368e-04) * 3.178 cp_fg=(cp_m1fg 
+ + cp_m2fg + cp_m3fg) * 0.828 cp_fge=(cp_m1fge + cp_m2fge + cp_m3fge) * 3.85 cpb=j1 
+ * (0.072592) * (1) + j2 * (0.035557) * (0.75) + j3 * (0.020533) * (0.868) cm1pk=(0.072592) 
+ * (1) cp_finger=(cp_fg * (nr / 2 - 1) + cp_fge) * (ll + ftip * 1e6) cp_bus=cpb 
+ * lnr * 0.651 cp_pk=j1 * cm1pk * (ll + ftip * 1e6 + 2 * wb * 1e6) mis=((mismatchflag 
+ - 1) / (0 - 1) * (0) + (mismatchflag - 0) / (1 - 0) * (2.3014)) geo_fac=1 / sqrt((cfinger 
+ + cedge + cedge2) * mf) factmis=mis / 1.414 / 100 * par_fmom * geo_fac 
// 
// 
cab ( a b ) bsource q=(1+factmis)*(cfinger+cedge+cedge2)*(tfac)*(v(a,b)+vcc1*1/2*v(a,b)**2+vcc2*1/3*v(a,b)**3)*1e-15*mf*fmom_fac
cpa ( a p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(a,p)+vcc1*1/2*v(a,p)**2+vcc2*1/3*v(a,p)**3)*1e-15*mf*fmom_fac2
cpb ( b p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(b,p)+vcc1*1/2*v(b,p)**2+vcc2*1/3*v(b,p)**3)*1e-15*mf*fmom_fac2
 
ends cfmom
 
// ******************************************************************************************
//                                                                            
//                *
// 0.18umBB FMOM   MULTI-X-COUPLE MISMATCH APPLICATION                        
//   		  *
// (FMOM multi-x-couple type device is only valid in array number=2)  		      
//      *
//            parameter range: nr :8~290(should be even fingers)				  *
//                             lr :3u ~ 168u						  *
//                             w(width):0.28u ~ 0.32u				    	  *
//                             s(spacing):0.28u ~ 0.32u					  *
//                             stm(start metal layer):M1,M2,M3                
//       	  *
//                             spm(stop metal layer):M3,M4,M5                 
//     		  *
//                             Total metal is at least 3 layers stacked with ploy 
//  shield    *
//              		     L Bus metal width (with via) : 0.28um (Non scalable)   
//        *		
//              		     Dummy Bus Width = finger width                         
//        *		
//               		     Dummy Bus Space = finger space                        
//         *			
//                             Ftip = 0.5um (Non scalable)          	         
//           *
//                             Distance between DBW and pickup metal : 0.5um (Non 
//  scalable) *
//                             mismatchflag=0 for no mismatch                 
//                *
//                             mismatchflag=1 for multi-x-couple              
//                *
//                                                                            
//                *
// ******************************************************************************************
 
subckt cfmom_mx ( a b a1 b1 p ) 
parameters nr=8 lr=167.5u w=0.32u s=0.32u stm=2 spm=5 mf=1 factor=1 mismatchflag=mismatchflag_fmom 
+ ww=w * 1e6 * factor ss=s * 1e6 * factor ll=lr * 1e6 * factor layno=spm - stm + 
+ 1 lnr=nr * (ww + ss) - ss j1=(stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) * (stm 
+ - 6) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) / (1 - 6) j2=(stm - 1) * (stm - 3) 
+ * (stm - 4) * (stm - 5) * (stm - 6) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) / 
+ (2 - 6) j3=(stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) * (stm - 6) / (3 - 1) 
+ / (3 - 2) / (3 - 4) / (3 - 5) / (3 - 6) tcc1=24.002 * 1e-6 tcc2=0.033 * 1e-6 vcc1=0.6976 
+ * 1e-6 vcc2= - 0.5168 * 1e-6 tfac=1 + tcc1 * (temp - 25) + tcc2 * (temp - 
+ 25) * (temp - 25) wb=0.28 * 1e-6 ftip=0.5 * 1e-6 cfg=((1.58502456697802e-03 
+ / ww + 4.97834615382138e-02 / ss +  - 8.69991468352519e-03 / ww / ss + 0.141092575577826)) 
+ * (0.887) cfg_t=(( - 1.45133875490407e-03 / ww + 0.051901629507603 / ss +  - 1.7164057841426e-03 
+ / ww / ss + 0.058158748650859)) * (0.86) cfg_b=(( - 7.51670687057387e-04 / ww 
+ + 5.19814417344521e-02 / ss +  - 1.45077745025167e-03 / ww / ss + 4.69794855516748e-02)) 
+ * (0.92) cfg_b_m1=((6.65867866332224e-04 / ww + 5.27140572153396e-02 / ss +  - 
+ 1.35294557061935e-03 / ww / ss + 0.021114140335185)) * (1) cfge=(( - 3.58921897506737e-03 
+ / ww + 2.17531337273711e-02 / ss + 2.22078239338076e-04 / ww / ss + 3.39251743618729e-02)) 
+ * (1.03) cfge_t=(( - 2.067472379465e-04 / ww + 1.89594574185258e-02 / ss +  - 
+ 5.90024678651475e-04 / ww / ss + 4.78083405448536e-02)) * (0.59) cfge_b=(( - 4.08481609189726e-03 
+ / ww + 2.07839555057359e-02 / ss + 5.31365394776244e-04 / ww / ss + 3.24968359914656e-02)) 
+ * (1.19) cfge_b_m1=((2.0613984133751e-03 / ww + 2.68051143896327e-02 / ss +  - 
+ 1.14880307083888e-03 / ww / ss + 1.08626496746679e-03)) * (1) cbus=(0.066188) 
+ * (1.52) cbus_t=(0.070721) * (1) cbus_b=(0.062123) * (1.62) cbus_b_m1=(0.052392) 
+ * (1) cfinger=((layno - 2) * cfg + cfg_t + cfg_b * (j2 + j3) + cfg_b_m1 * j1) 
+ / 2 * (nr - 3) * ll cedge=((layno - 2) * cfge + cfge_t + cfge_b * (j2 + j3) + 
+ cfge_b_m1 * j1) * ll * 2 cedge2=((layno - 2) * cbus + cbus_t + cbus_b * (j2 + 
+ j3) + cbus_b_m1 * j1) * nr * ww cp_m1fg=j1 * (7.07541668838077e-02 * ww + 6.21037700315025e-02 
+ * ss + 6.24999341603259e-04 * ww * ss + 1.28949596878795e-03) * 0.988 cp_m2fg=j2 
+ * (1.80585317457402e-02 * ww + 1.73843253965345e-02 * ss +  - 2.97619037915623e-05 
+ * ww * ss + 8.04933863307867e-05) * 1.103 cp_m3fg=j3 * (1.03166466568724e-02 * 
+ ww + 1.00910117360319e-02 * ss + 5.05958000334281e-05 * ww * ss + 3.52388072156329e-05) 
+ * 1.116 cp_m1fge=j1 * (0.135273359618694 * ww + 1.35405398464984e-02 * ss +  - 
+ 0.247736013611283 * ww * ss +  - 2.34920544459968e-03) * 1 cp_m2fge=j2 * (9.96401910145081e-04 
+ * ww +  - 4.1542717932859e-03 * ss +  - 8.39105828027469e-05 * ww * ss + 1.56738096602432e-02) 
+ * 0.881 cp_m3fge=j3 * (6.16953923242438e-03 * ww + 1.87598430851836e-03 * ss + 
+ 8.26070374619411e-03 * ww * ss +  - 8.46620765503368e-04) * 3.178 cp_fg=(cp_m1fg 
+ + cp_m2fg + cp_m3fg) * 0.828 cp_fge=(cp_m1fge + cp_m2fge + cp_m3fge) * 3.85 cpb=j1 
+ * (0.072592) * (1) + j2 * (0.035557) * (0.75) + j3 * (0.020533) * (0.868) cm1pk=(0.072592) 
+ * (1) cp_finger=(cp_fg * (nr / 2 - 1) + cp_fge) * (ll + ftip * 1e6) cp_bus=cpb 
+ * lnr * 0.651 cp_pk=j1 * cm1pk * (ll + ftip * 1e6 + 2 * wb * 1e6) mis=((mismatchflag 
+ - 1) / (0 - 1) * (0) + (mismatchflag - 0) / (1 - 0) * (0.6796)) geo_fac=1 / sqrt((cfinger 
+ + cedge + cedge2) * mf) factmis=mis / 1.414 / 100 * par_fmom * geo_fac 
// 
// 
cab ( a b ) bsource q=(1+factmis)*(cfinger+cedge+cedge2)*(tfac)*(v(a,b)+vcc1*1/2*v(a,b)**2+vcc2*1/3*v(a,b)**3)*1e-15*mf*fmom_fac
cpa ( a p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(a,p)+vcc1*1/2*v(a,p)**2+vcc2*1/3*v(a,p)**3)*1e-15*mf*fmom_fac2
cpb ( b p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(b,p)+vcc1*1/2*v(b,p)**2+vcc2*1/3*v(b,p)**3)*1e-15*mf*fmom_fac2
 
ca1b1 ( a1 b1 ) bsource q=(1+factmis)*((cfinger+cedge+cedge2)*(tfac)*(v(a1,b1)+vcc1*1/2*v(a1,b1)**2+vcc2*1/3*v(a1,b1)**3)*1e-15*mf*fmom_fac)
cpa1 ( a1 p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(a1,p)+vcc1*1/2*v(a1,p)**2+vcc2*1/3*v(a1,p)**3)*1e-15*mf*fmom_fac2
cpb1 ( b1 p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(b1,p)+vcc1*1/2*v(b1,p)**2+vcc2*1/3*v(b1,p)**3)*1e-15*mf*fmom_fac2
 
ends cfmom_mx
 
endsection fmom
endlibrary tsmclib
