+ pdiblc1=0                 pdiblc2=0.00011341635     lpdiblc2=2.8983749e-010
+ wpdiblc2=6.3610082e-011   ppdiblc2=-3.8325399e-016  pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.28832318           lkt1=-5.3788051e-009      wkt1=-2.9848587e-008
+ pkt1=5.3933279e-014       kt1l=0                    kt2=-0.055405114
+ lkt2=2.648582e-009        wkt2=1.3980828e-009       pkt2=-3.7537412e-029
+ ute=-1.085633             lute=1.912681e-008        wute=-1.7802388e-007
+ pute=1.4682146e-013       ua1=1.1904083e-009        lua1=1.8483094e-016
+ wua1=5.0288392e-016       pua1=-9.1980958e-022      ub1=-2.6903002e-018
+ lub1=-7.8117878e-025      wub1=-1.3787605e-024      pub1=1.4060052e-030
+ uc1=-1.1218049e-010       luc1=2.0030768e-017       wuc1=1.753825e-016
+ puc1=-2.8536722e-022      prt=0                     at=168710.34
+ lat=-0.086833378          wat=-9.2860183e-005       pat=9.2572317e-010
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          ngcon=1                   wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     7: type=p 
+ lmin=5e-007-(dxlp_3v+dlmisp_3v)                     lmax=1.2e-006-(dxlp_3v+dlmisp_3v)
+ wmin=1.23e-006-(dxwp_3v+dwmisp_3v)                  wmax=1.003e-005-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.70843768+(dvthp_3v+vthmisp_3v)
+ lvth0=-1.1178348e-008+dlvthp_3v                     wvth0=1.873431e-010+dwvthp_3v
+ pvth0=-2.1900408e-016+dpvthp_3v                     k1=0.83978
+ k2=0.058562671+dk2p_3v    lk2=1.2066673e-009        wk2=1.018573e-008
+ pk2=-7.1176218e-016       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.13531975
+ lvoff=5.6481563e-010      wvoff=6.515066e-009       pvoff=2.1900408e-015
+ nfactor=1                 eta0=0.092788636          weta0=-2.7961657e-008
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.011825+du0p_3v
+ lu0=1.958075e-009         ua=2.290934e-009          lua=1.6332439e-016
+ wua=-2.3908335e-016       pua=5.0633744e-022        ub=-7.6256581e-019
+ lub=7.4136627e-025        wub=3.2182466e-025        pub=-8.2893044e-031
+ uc=-7.3444704e-011        luc=7.9067128e-017        wuc=-5.8980808e-017
+ puc=2.4502176e-023        vsat=80000+dvsatp_3v      a0=0.98900166
+ la0=-1.4017673e-007       wa0=2.376437e-008         pa0=-2.7780613e-014
+ ags=0.024415956           lags=2.6302514e-007       wags=1.1234295e-007
+ pags=-1.713707e-013       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.016946534
+ lketa=-1.1729121e-008     wketa=1.3292932e-008      pketa=-1.5539437e-014
+ dwg=0                     dwb=0                     pclm=0.23946161
+ lpclm=-5.782062e-008      wpclm=-1.2645659e-007     ppclm=1.4782776e-013
+ pdiblc1=0                 pdiblc2=0.00051400853     lpdiblc2=-1.7845477e-010
+ wpdiblc2=-6.1925281e-010  ppdiblc2=4.1501273e-016   pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.29510105           lkt1=2.5445274e-009       wkt1=3.8113136e-008
+ pkt1=-2.5513976e-014      kt1l=0                    kt2=-0.055149432
+ lkt2=2.34969e-009         wkt2=1.3980828e-009       pkt2=2.0800544e-030
+ ute=-1.0081169            lute=-7.1489487e-008      wute=-2.4045627e-008
+ pute=-3.3179119e-014      ua1=1.4251478e-009        lua1=-8.9579546e-017
+ wua1=-3.6975377e-016      pua1=1.0030387e-022       ub1=-3.042043e-018
+ lub1=-3.6999143e-025      wub1=4.0380827e-025       pub1=-6.7781764e-031
+ uc1=-7.8896996e-011       luc1=-1.8877638e-017      wuc1=-3.0989485e-017
+ puc1=-4.4118373e-023      prt=0                     at=138276.84
+ lat=-0.051256616          wat=-0.0039808032         pat=5.4707286e-009
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          ngcon=1                   wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     8: type=p 
+ lmin=3e-07                lmax=5e-007-(dxlp_3v+dlmisp_3v)
+ wmin=1.23e-006-(dxwp_3v+dwmisp_3v)                  wmax=1.003e-005-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72794375+(dvthp_3v+vthmisp_3v)
+ lvth0=-2.0300022e-009+dlvthp_3v                     wvth0=3.3191885e-008+dwvthp_3v
+ pvth0=-1.5698134e-014+dpvthp_3v                     k1=0.83978
+ k2=0.044872486+dk2p_3v    lk2=7.6273643e-009        wk2=3.6874435e-008
+ pk2=-1.3228765e-014       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1348011
+ lvoff=3.2156719e-010      wvoff=4.5032248e-008      pvoff=-1.5874518e-014
+ nfactor=1                 eta0=0.092788636          weta0=-2.7961657e-008
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.010823661+du0p_3v
+ lu0=2.4277032e-009        wu0=4.7010536e-009        pu0=-2.2047941e-015
+ ua=3.1086115e-009         lua=-2.2016636e-016       wua=-1.0047301e-015
+ pua=8.6542579e-022        ub=-1.4455767e-018        lub=1.0616984e-024
+ wub=3.3701414e-024        pub=-2.258591e-030        uc=-1.5978864e-010
+ luc=1.1956244e-016        wuc=2.0067498e-016        puc=-9.727639e-023
+ vsat=80000+dvsatp_3v      a0=1.0460431              la0=-1.6692914e-007
+ wa0=1.6092035e-006        pa0=-7.7135154e-013       ags=0.12027096
+ lags=2.1806915e-007       wags=-7.1563666e-007      pags=2.1695174e-013
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.010567386         lketa=-1.4720942e-008
+ wketa=-4.5541802e-008     pketa=1.2054053e-014      dwg=0
+ dwb=0                     pclm=-0.059742418         lpclm=8.2506068e-008
+ wpclm=5.3661915e-007      ppclm=-1.6315476e-013     pdiblc1=0
+ pdiblc2=4.0851229e-005    lpdiblc2=4.3456004e-011   wpdiblc2=-6.9337937e-010
+ ppdiblc2=4.4977809e-016   pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.19113786
+ lkt1=-4.6214211e-008      wkt1=-5.111307e-008       pkt1=1.6333115e-014
+ kt1l=0                    kt2=-0.056676896          lkt2=3.0660708e-009
+ wkt2=-4.823367e-010       pkt2=8.8191676e-016       ute=-0.96409119
+ lute=-9.213755e-008       wute=4.2627476e-007       pute=-2.4437938e-013
+ ua1=-1.5257798e-009       lua1=1.2944055e-015       wua1=4.2351232e-015
+ pua1=-2.0593834e-021      ub1=-8.27956e-019         lub1=-1.4083982e-024
+ wub1=-3.0805611e-024      pub1=9.5635158e-031       uc1=2.887394e-011
+ luc1=-6.9422207e-017      wuc1=-1.0204217e-016      puc1=-1.0794663e-023
+ prt=0                     at=61251.105              lat=-0.015131547
+ wat=0.018018662           pat=-4.8470208e-009       jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1e-005              sbref=1e-005              wlod=5e-006
+ kvth0=-1.8e-009           lkvth0=-1e-011            wkvth0=4e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=6.38e-008             lku0=2.55e-007            wku0=1e-008
+ pku0=-2.5e-013            llodku0=1                 wlodku0=1
+ kvsat=-1                  steta0=-3e-010            tku0=0.5
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     9: type=p 
+ lmin=1e-005-(dxlp_3v+dlmisp_3v)                     lmax=0.00090001
+ wmin=5.3e-007-(dxwp_3v+dwmisp_3v)                   wmax=1.23e-006-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72309043+(dvthp_3v+vthmisp_3v)
+ wvth0=-1.1177444e-008+dwvthp_3v                     k1=0.83978
+ k2=0.067892+dk2p_3v       wk2=2.586516e-009         k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13951143          wvoff=3.6950229e-009      nfactor=1
+ eta0=0.07                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.012247143+du0p_3v    wu0=9.2375571e-010        ua=1.8115011e-009
+ wua=2.582821e-016         ub=2.4906e-019            wub=-5.0437062e-025
+ uc=-2.7299251e-011        wuc=-4.8415885e-017       vsat=80000+dvsatp_3v
+ a0=0.98633722             wa0=-5.0843515e-008       ags=0.15175914
+ wags=-3.5287469e-008      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.013606051
+ wketa=3.8638856e-009      dwg=0                     dwb=0
+ pclm=0.11235714           wpclm=4.6187786e-008      pdiblc1=0
+ pdiblc2=0.00015998858     wpdiblc2=3.6950229e-012   pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.32193994           wkt1=1.6147241e-008       kt1l=0
+ kt2=-0.055505714          wkt2=1.8475114e-009       ute=-1.1485159
+ wute=-8.3784643e-008      ua1=2.2699264e-009        wua1=-8.9120252e-016
+ ub1=-4.7508443e-018       wub1=1.1944161e-024       uc1=7.904829e-011
+ wuc1=-8.5415258e-017      prt=0                     at=160000
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  lvth0=0+dlvthp_3v         pvth0=0+dpvthp_3v
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
     10: type=p 
+ lmin=1.2e-006-(dxlp_3v+dlmisp_3v)                   lmax=1e-005-(dxlp_3v+dlmisp_3v)
+ wmin=5.3e-007-(dxwp_3v+dwmisp_3v)                   wmax=1.23e-006-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72785706+(dvthp_3v+vthmisp_3v)
+ lvth0=4.7518589e-008+dlvthp_3v                      wvth0=-7.6433227e-009+dwvthp_3v
+ pvth0=-3.5231656e-014+dpvthp_3v                     k1=0.83978
+ k2=0.068267389+dk2p_3v    lk2=-3.7422572e-009       wk2=2.5497022e-009
+ pk2=3.6699642e-016        k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.14344086
+ lvoff=3.9172528e-008      wvoff=7.1309742e-009      pvoff=-3.4252999e-014
+ nfactor=1                 eta0=0.07                 etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.012130717+du0p_3v    lu0=1.1606465e-009
+ wu0=9.8511199e-010        pu0=-6.116607e-016        ua=1.6803612e-009
+ lua=1.307334e-015         wua=3.2680479e-016        pua=-6.8310267e-022
+ ub=3.4622724e-019         lub=-9.6866025e-025       wub=-5.7763001e-025
+ pub=7.3032288e-031        uc=-2.6684694e-011        luc=-6.126526e-018
+ wuc=-5.405379e-017        puc=5.6204278e-023        vsat=80000+dvsatp_3v
+ a0=1.0008703              la0=-1.4488073e-007       wa0=-5.6318948e-008
+ pa0=5.4584601e-014        ags=0.14199465            lags=9.73422e-008
+ wags=-3.9361526e-008      pags=4.0614272e-014       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.011829443         lketa=-1.7711001e-008     wketa=4.3771677e-009
+ pketa=-5.116909e-015      dwg=0                     dwb=0
+ pclm=0.1030431            lpclm=9.2851719e-008      wpclm=5.1096288e-008
+ ppclm=-4.8932856e-014     pdiblc1=0                 pdiblc2=0.00016554721
+ lpdiblc2=-5.5414012e-011  wpdiblc2=-3.5449126e-013  ppdiblc2=4.0369606e-017
+ pdiblcb=0                 drout=0.5                 pvag=1.2
+ delta=0.01                pscbe1=2.5e+008           pscbe2=3e-007
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14322
+ beta0=16.108              agidl=6.2e-010            bgidl=1.8206e+009
+ cgidl=60                  egidl=0.13                aigbacc=0.01095
+ bigbacc=0.00456           cigbacc=0.2247            nigbacc=4.046
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.005943
+ bigc=0.0006147            cigc=1e-010               aigsd=0.00452
+ bigsd=0                   cigsd=0.002267            nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_3v
+ cgdo=cgop_3v              cgbo=0                    cgdl=cglp_3v
+ cgsl=cglp_3v              clc=1e-007                cle=0.6
+ cf=cfp_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5.1                  noff=1.679
+ voffcv=-0.075642          kt1=-0.32872289           lkt1=6.7619255e-008
+ wkt1=1.9721856e-008       pkt1=-3.563534e-014       kt1l=0
+ kt2=-0.055771396          lkt2=2.648582e-009        wkt2=1.8475114e-009
+ pkt2=-2.2066341e-029      ute=-1.1217584            lute=-2.6674487e-007
+ wute=-1.3369798e-007      pute=4.97586e-013         ua1=2.599777e-009
+ lua1=-3.2882804e-015      wua1=-1.2264115e-015      pua1=3.3416981e-021
+ ub1=-4.9954399e-018       lub1=2.4383741e-024       wub1=1.449646e-024
+ pub1=-2.5443862e-030      uc1=1.0718684e-010        luc1=-2.8051316e-016
+ wuc1=-9.378121e-017       puc1=8.3400182e-023       prt=0
+ at=168434.64              lat=-0.084084914          wat=0.0002454251
+ pat=-2.4466428e-009       jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          ngcon=1
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     11: type=p 
+ lmin=5e-007-(dxlp_3v+dlmisp_3v)                     lmax=1.2e-006-(dxlp_3v+dlmisp_3v)
+ wmin=5.3e-007-(dxwp_3v+dwmisp_3v)                   wmax=1.23e-006-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.65615642+(dvthp_3v+vthmisp_3v)
+ lvth0=-3.6299466e-008+dlvthp_3v                     wvth0=-6.3961769e-008+dwvthp_3v
+ pvth0=3.0604608e-014+dpvthp_3v                      k1=0.83978
+ k2=0.064126611+dk2p_3v    lk2=1.0983122e-009        wk2=3.3587758e-009
+ pk2=-5.7881055e-016       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.10765391
+ lvoff=-2.6624226e-009     wvoff=-2.7430926e-008     pvoff=6.1498621e-015
+ nfactor=1                 eta0=0.07                 etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.01069195+du0p_3v     lu0=2.8425655e-009
+ wu0=1.3902524e-009        pu0=-1.0852698e-015       ua=2.2921576e-009
+ lua=5.9214403e-016        wua=-2.4058479e-016       pua=-1.9824261e-023
+ ub=-8.478817e-019         lub=4.2725311e-025        wub=4.2650726e-025
+ pub=-4.4351359e-031       uc=-1.2453237e-010        luc=1.0825741e-016
+ wuc=3.703761e-018         puc=-1.1314299e-023       vsat=80000+dvsatp_3v
+ a0=0.98231765             la0=-1.2319264e-007       wa0=3.1965649e-008
+ pa0=-4.8620094e-014       ags=0.063244886           lags=1.8940068e-007
+ wags=6.469985e-008        pags=-8.1033477e-014      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.0074157514        lketa=-2.2870607e-008     wketa=1.5986609e-009
+ pketa=-1.8688346e-015     dwg=0                     dwb=0
+ pclm=0.113739             lpclm=8.0348209e-008      wpclm=2.7805047e-008
+ ppclm=-2.1705396e-014     pdiblc1=0                 pdiblc2=-2.2066598e-005
+ lpdiblc2=1.6390653e-010   wpdiblc2=3.8511376e-011   ppdiblc2=-5.0645923e-018
+ pdiblcb=0                 drout=0.5                 pvag=1.2
+ delta=0.01                pscbe1=2.5e+008           pscbe2=3e-007
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14322
+ beta0=16.108              agidl=6.2e-010            bgidl=1.8206e+009
+ cgidl=60                  egidl=0.13                aigbacc=0.01095
+ bigbacc=0.00456           cigbacc=0.2247            nigbacc=4.046
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.005943
+ bigc=0.0006147            cigc=1e-010               aigsd=0.00452
+ bigsd=0                   cigsd=0.002267            nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_3v
+ cgdo=cgop_3v              cgbo=0                    cgdl=cglp_3v
+ cgsl=cglp_3v              clc=1e-007                cle=0.6
+ cf=cfp_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5.1                  noff=1.679
+ voffcv=-0.075642          kt1=-0.24351536           lkt1=-3.1988344e-008
+ wkt1=-2.5182505e-008      pkt1=1.6857857e-014       kt1l=0
+ kt2=-0.056020129          lkt2=2.9393503e-009       wkt2=2.4664278e-009
+ pkt2=-7.2351319e-016      ute=-1.2905272            lute=-6.9454185e-008
+ wute=3.2247178e-007       pute=-3.5676435e-014      ua1=-6.3164448e-010
+ lua1=4.8925127e-016       wua1=2.1539304e-015       pua1=-6.0992155e-022
+ ub1=-1.5161789e-018       lub1=-1.6288821e-024      wub1=-1.468427e-024
+ pub1=8.6684115e-031       uc1=-1.0236075e-010       luc1=-3.5552035e-017
+ wuc1=-2.1994562e-018      puc1=-2.3658888e-023      prt=0
+ at=131367.97              lat=-0.040753977          wat=0.0044963809
+ pat=-7.4160102e-009       jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          ngcon=1
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
     12: type=p 
+ lmin=3e-07                lmax=5e-007-(dxlp_3v+dlmisp_3v)
+ wmin=5.3e-007-(dxwp_3v+dwmisp_3v)                   wmax=1.23e-006-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.69809865+(dvthp_3v+vthmisp_3v)
+ lvth0=-1.662856e-008+dlvthp_3v                      wvth0=-3.4280575e-009+dwvthp_3v
+ pvth0=2.2142969e-015+dpvthp_3v                      k1=0.83978
+ k2=0.077750096+dk2p_3v    lk2=-5.2911022e-009       wk2=-3.4663933e-009
+ pk2=2.6221938e-015        k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.067697746
+ lvoff=-2.1401862e-008     wvoff=-3.7303565e-008     pvoff=1.078013e-014
+ nfactor=1                 eta0=0.07                 etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.017433043+du0p_3v    lu0=-3.190071e-010
+ wu0=-3.4086586e-009       pu0=1.1654194e-015        ua=2.508033e-009
+ lua=4.9089849e-016        wua=-2.6782034e-016       pua=-7.0507877e-024
+ ub=2.9362543e-018         lub=-1.3475067e-024       wub=-2.0063652e-024
+ pub=6.9750358e-031        uc=7.3874286e-011         luc=1.5204687e-017
+ wuc=-8.6029432e-017       puc=3.0770569e-023        vsat=80000+dvsatp_3v
+ a0=2.7983494              la0=-9.7491152e-007       wa0=-5.4087643e-007
+ pa0=2.2004284e-013        ags=-0.26147532           lags=3.4169446e-007
+ wags=-2.4723397e-007      pags=6.5263483e-014       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.057949996         lketa=8.2995411e-010      wketa=1.2596661e-008
+ pketa=-7.0268966e-015     dwg=0                     dwb=0
+ pclm=0.44328679           lpclm=-7.4209703e-008     wpclm=-8.0597686e-008
+ ppclm=2.9135486e-014      pdiblc1=0                 pdiblc2=-0.0013872878
+ lpdiblc2=8.041953e-010    wpdiblc2=1.0589473e-009   ppdiblc2=-4.8364903e-016
+ pdiblcb=0                 drout=0.5                 pvag=1.2
+ delta=0.01                pscbe1=2.5e+008           pscbe2=3e-007
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14322
+ beta0=16.108              agidl=6.2e-010            bgidl=1.8206e+009
+ cgidl=60                  egidl=0.13                aigbacc=0.01095
+ bigbacc=0.00456           cigbacc=0.2247            nigbacc=4.046
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.005943
+ bigc=0.0006147            cigc=1e-010               aigsd=0.00452
+ bigsd=0                   cigsd=0.002267            nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_3v
+ cgdo=cgop_3v              cgbo=0                    cgdl=cglp_3v
+ cgsl=cglp_3v              clc=1e-007                cle=0.6
+ cf=cfp_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5.1                  noff=1.679
+ voffcv=-0.075642          kt1=-0.20486922           lkt1=-5.0113384e-008
+ wkt1=-3.4264686e-008      pkt1=2.11174e-014         kt1l=0
+ kt2=-0.060860634          lkt2=5.2095475e-009       wkt2=4.65111e-009
+ pkt2=-1.7481292e-015      ute=-1.0933669            lute=-1.6192234e-007
+ wute=5.8489611e-007       pute=-1.5875345e-013      ua1=-1.2380198e-010
+ lua1=2.5107314e-016       wua1=2.5148964e-015       pua1=-7.7921462e-022
+ ub1=-2.9836109e-018       lub1=-9.4065644e-025      wub1=-4.3557253e-025
+ pub1=3.8243239e-031       uc1=1.1485528e-010        luc1=-1.3742636e-016
+ wuc1=-2.0754128e-016      puc1=7.2646427e-023       prt=0
+ at=97563.004              lat=-0.024899448          wat=-0.026536038
+ pat=7.1381941e-009        jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          ngcon=1
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     13: type=p 
+ lmin=1e-005-(dxlp_3v+dlmisp_3v)                     lmax=0.00090001
+ wmin=2.2e-07              wmax=5.3e-007-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.74870999+(dvthp_3v+vthmisp_3v)
+ wvth0=2.3240663e-009+dwvthp_3v                      k1=0.83978
+ k2=0.07805+dk2p_3v        wk2=-2.76675e-009         k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.12375             wvoff=-4.61125e-009       nfactor=1
+ eta0=0.077                weta0=-3.689e-009         etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.01435+du0p_3v        wu0=-1.8445e-010
+ ua=2.36215e-009           wua=-3.190985e-017        ub=-2.18e-019
+ wub=-2.5823e-025          uc=-6.2743e-011           wuc=-2.9737029e-017
+ vsat=80000+dvsatp_3v      a0=0.88985993             wa0=1.4756e-014
+ ags=0.095859998           wags=-5.8286196e-009      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.01180805          wketa=2.9163388e-009      dwg=0
+ dwb=0                     pclm=0.2                  pdiblc1=0
+ pdiblc2=-0.00010109998    wpdiblc2=1.412887e-010    pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.30149202           wkt1=5.3711877e-009       kt1l=0
+ kt2=-0.0534               wkt2=7.378e-010           ute=-1.36196
+ wute=2.870042e-008        ua1=4.7221611e-010        wua1=5.6190819e-017
+ ub1=-2.63987e-018         wub1=8.193269e-026        uc1=-1.296262e-010
+ wuc1=2.4556198e-017       prt=0                     at=160000
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  lvth0=0+dlvthp_3v
+ pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     14: type=p 
+ lmin=1.2e-006-(dxlp_3v+dlmisp_3v)                   lmax=1e-005-(dxlp_3v+dlmisp_3v)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.744483+(dvthp_3v+vthmisp_3v)
+ lvth0=-4.213894e-008+dlvthp_3v                      wvth0=1.118543e-009+dwvthp_3v
+ pvth0=1.2017862e-014+dpvthp_3v                      k1=0.83978
+ k2=0.078327638+dk2p_3v    lk2=-2.7677682e-009       wk2=-2.7520485e-009
+ pk2=-1.4655929e-016       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1195323
+ lvoff=-4.204624e-008      wvoff=-5.4688377e-009     pvoff=8.5492918e-015
+ nfactor=1                 eta0=0.077                weta0=-3.689e-009
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.01435+du0p_3v
+ wu0=-1.8445e-010          ua=2.3835467e-009         lua=-2.1330356e-016
+ wua=-4.3773963e-017       pua=1.1827335e-022        ub=-3.0643219e-019
+ lub=8.8158051e-025        wub=-2.3367849e-025       pub=-2.4475401e-031
+ uc=-7.541229e-011         luc=1.2630015e-016        wuc=-2.8374347e-017
+ puc=-1.358458e-023        vsat=80000+dvsatp_3v      a0=0.87557661
+ la0=1.4239042e-007        wa0=9.7108478e-009        pa0=-9.6807295e-014
+ ags=0.065560315           lags=3.0205755e-007       wags=9.1937068e-010
+ pags=-6.7270715e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.0091172174
+ lketa=-2.6824906e-008     wketa=2.9478245e-009      pketa=-3.1388095e-016
+ dwg=0                     dwb=0                     pclm=0.2
+ pdiblc1=0                 pdiblc2=-0.00012284604    lpdiblc2=2.1678643e-010
+ wpdiblc2=1.5162875e-010   ppdiblc2=-1.0308003e-016  pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.29851173           lkt1=-2.9710447e-008      wkt1=3.8005776e-009
+ pkt1=1.5657412e-014       kt1l=0                    kt2=-0.053665682
+ lkt2=2.648582e-009        wkt2=7.378e-010           pkt2=-1.6560538e-030
+ ute=-1.4674961            lute=1.0520898e-006       wute=4.8505801e-008
+ pute=-1.9743985e-013      ua1=-1.1093802e-010       lua1=5.8134635e-015
+ wua1=2.0213534e-016       pua1=-1.454921e-021       ub1=-2.1595133e-018
+ lub1=-4.7886759e-024      wub1=-4.4887369e-026      pub1=1.2642692e-030
+ uc1=-1.0815282e-010       luc1=-2.1406807e-016      wuc1=1.970279e-017
+ puc1=4.8383618e-023       prt=0                     at=167250.72
+ lat=-0.072282452          wat=0.000869349           pat=-8.6665402e-009
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
     15: type=p 
+ lmin=5e-007-(dxlp_3v+dlmisp_3v)                     lmax=1.2e-006-(dxlp_3v+dlmisp_3v)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.80253279+(dvthp_3v+vthmisp_3v)
+ lvth0=2.5721268e-008+dlvthp_3v                      wvth0=1.3178577e-008+dwvthp_3v
+ pvth0=-2.0803187e-015+dpvthp_3v                     k1=0.83978
+ k2=0.0737557+dk2p_3v      lk2=2.5768267e-009        wk2=-1.7157539e-009
+ pk2=-1.3579877e-015       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1578115
+ lvoff=2.7021435e-009      wvoff=-9.978745e-010      pvoff=3.3227358e-015
+ nfactor=1                 eta0=0.077                weta0=-3.689e-009
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0143835+du0p_3v
+ lu0=-3.9161501e-011       wu0=-5.551945e-010        pu0=4.3340032e-016
+ ua=1.9398336e-009         lua=3.0539699e-016        wua=-5.4910052e-017
+ pua=1.3129143e-022        ub=7.0035697e-019         lub=-2.9535602e-025
+ wub=-3.8941452e-025       pub=-6.2698583e-032       uc=-6.2567387e-011
+ luc=1.1128446e-016        wuc=-2.8951786e-017       puc=-1.2909554e-023
+ vsat=80000+dvsatp_3v      a0=1.2527249              la0=-2.9849597e-007
+ wa0=-1.1053899e-007       pa0=4.3764764e-014        ags=0.3738985
+ lags=-5.8389799e-008      wags=-9.9014607e-008      pags=4.9552105e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0093336119        lketa=-2.6571941e-008
+ wketa=2.6093733e-009      pketa=8.1768483e-017      dwg=0
+ dwb=0                     pclm=0.122883             lpclm=9.0149773e-008
+ wpclm=2.2986159e-008      ppclm=-2.687082e-014      pdiblc1=0
+ pdiblc2=-0.00028137796    lpdiblc2=4.0211025e-010   wpdiblc2=1.7516847e-010
+ ppdiblc2=-1.3059795e-016  pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.29355925
+ lkt1=-3.54999e-008        wkt1=1.1906248e-009       pkt1=1.8708447e-014
+ kt1l=0                    kt2=-0.051333             lkt2=-7.8323002e-011
+ wkt2=-3.689e-012          pkt2=8.6680064e-016       ute=-0.36242656
+ lute=-2.3973658e-007      wute=-1.6663725e-007      pute=5.4062385e-014
+ ua1=5.9153443e-009        lua1=-1.2312605e-015      wua1=-1.2963327e-015
+ pua1=2.9678817e-022       ub1=-6.4159425e-018       lub1=1.8708985e-025
+ wub1=1.1137484e-024       pub1=-9.0176045e-032      uc1=-2.4967621e-010
+ luc1=-4.8627239e-017      wuc1=7.5435788e-017       puc1=-1.6768256e-023
+ prt=0                     at=156886.06              lat=-0.060166167
+ wat=-0.0089516554         pat=2.8142139e-009        jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1e-005              sbref=1e-005              wlod=5e-006
+ kvth0=-1.8e-009           lkvth0=-1e-011            wkvth0=4e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=6.38e-008             lku0=2.55e-007            wku0=1e-008
+ pku0=-2.5e-013            llodku0=1                 wlodku0=1
+ kvsat=-1                  steta0=-3e-010            tku0=0.5
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     16: type=p 
+ lmin=3e-07                lmax=5e-007-(dxlp_3v+dlmisp_3v)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwp_3v+dwmisp_3v)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_3v+toxmisp_3v)
+ toxm=6.794e-009           dtox=5.93e-010            epsrox=3.9
+ wint=1.4999999e-009       lint=8e-009               ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp_3v+dlmisp_3v)                     xw=0+(dxwp_3v+dwmisp_3v)
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72317065+(dvthp_3v+vthmisp_3v)
+ lvth0=-1.1499575e-008+dlvthp_3v                     wvth0=9.7848881e-009+dwvthp_3v
+ pvth0=-4.8867833e-016+dpvthp_3v                     k1=0.83978
+ k2=0.09150295+dk2p_3v     lk2=-5.7466336e-009       wk2=-1.0714147e-008
+ pk2=2.8622588e-015        k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.16368425
+ lvoff=5.4564633e-009      wvoff=1.3281322e-008      pvoff=-3.3742075e-015
+ nfactor=1                 eta0=0.077                weta0=-3.689e-009
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0112065+du0p_3v
+ lu0=1.4508515e-009        wu0=-1.272705e-010        pu0=2.3270396e-016
+ ua=8.5993122e-010         lua=8.1187122e-016        wua=6.0072929e-016
+ pua=-1.7620342e-022       ub=1.6111628e-018         lub=-7.2252396e-025
+ wub=-1.3080419e-024       pub=3.6813768e-031        uc=2.1025018e-011
+ luc=7.2079621e-017        wuc=-5.8177868e-017       puc=7.9747858e-025
+ vsat=80000+dvsatp_3v      a0=2.6408098              la0=-9.4950776e-007
+ wa0=-4.5785304e-007       pa0=2.0665506e-013        ags=-0.50501048
+ lags=3.5381851e-007       wags=-1.1889094e-007      pags=5.8874105e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.046434175         lketa=-9.1717764e-009
+ wketa=6.5278234e-009      pketa=-1.7559846e-015     dwg=0
+ dwb=0                     pclm=0.7725345            lpclm=-2.1453678e-007
+ wpclm=-2.5411123e-007     ppclm=1.0308786e-013      pdiblc1=0
+ pdiblc2=0.0011099645      lpdiblc2=-2.5042937e-010  wpdiblc2=-2.5710472e-010
+ ppdiblc2=7.2138173e-017   pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.47452786
+ lkt1=4.9374378e-008       wkt1=1.0784542e-007       pkt1=-3.131265e-014
+ kt1l=0                    kt2=-0.055534998          lkt2=1.8924139e-009
+ wkt2=1.8444995e-009       pkt2=2.3270396e-022       ute=0.61497069
+ lute=-6.9813589e-007      wute=-3.1539782e-007      pute=1.2383109e-013
+ ua1=8.8879497e-009        lua1=-2.6254125e-015      wua1=-2.2342967e-015
+ pua1=7.3669329e-022       ub1=-8.4397388e-018       lub1=1.1362503e-024
+ wub1=2.4398069e-024       pub1=-7.1209747e-031      uc1=-4.6003775e-010
+ luc1=5.0032324e-017       wuc1=9.5427347e-017       puc1=-2.6144297e-023
+ prt=0                     at=60341.988              lat=-0.014886995
+ wat=-0.0069205623         pat=1.8616313e-009        jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          rbsb=50
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
     } 
ends pch3_mac
// 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V NMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
model nch3 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_3v       lmax=900.01e-6            wmin=1.003e-005-dxwn_3v
+ wmax=900.01e-6            version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.721+dvthn_3v       k1=0.88
+ k2=0.01167+dk2n_3v        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=27.472               dvt1=0.45
+ dvt2=0                    dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.16                 minv=-0.3
+ voffl=-2.6873e-010        dvtp0=1.83e-006           dvtp1=0.13
+ lpe0=8e-008               lpeb=2.1249e-009          xj=1.4e-007
+ ngate=9.7e+019            ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.001                 voff=-0.1422
+ nfactor=1                 eta0=0.005                etab=-0.0097829
+ u0=0.04+du0n_3v           ua=-1.081e-009            ub=3.345e-018
+ uc=2.1489e-010            vsat=70000+dvsatn_3v      a0=1.35
+ ags=0.3105                a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.001
+ dwg=0                     dwb=0                     pclm=0.1
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.312
+ kt1l=0                    kt2=-0.0645               ute=-1.35
+ ua1=2.0192e-009           ub1=-2.185e-018           uc1=-7.5e-011
+ prt=0                     at=150000                 jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3v
+ cjd=cjn_3v                mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3v
+ cjswd=cjswn_3v            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3v
+ cjswgd=cjswgn_3v          mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=3.73e-010
+ jtsswgd=3.73e-010         njtsswg=60                xtsswgs=0.836
+ xtsswgd=0.836             tnjtsswg=3                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3v         wvth0=0+dwvthn_3v         pvth0=0+dpvthn_3v
+ pvsat=0+dpvsatn_3v        pat=0+dpatn_3v            lcit=0+dlcitn_3v
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ pcit=0+dpcitn_3v          fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
 
     2: type=n 
+ lmin=1.2e-006-dxln_3v     lmax=1e-005-dxln_3v       wmin=1.003e-005-dxwn_3v
+ wmax=900.01e-6            version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71865906+dvthn_3v  lvth0=2.3279393e-008+dlvthn_3v
+ k1=0.88                   k2=0.011899945+dk2n_3v    lk2=-2.2866831e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=27.472               dvt1=0.45                 dvt2=0
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.16                 minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=1.83e-006           dvtp1=0.13                lpe0=8e-008
+ lpeb=2.1249e-009          xj=1.4e-007               ngate=9.7e+019
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0010078031          lcit=-7.7597977e-011+dlcitn_3v
+ voff=-0.14036626          lvoff=-1.8235525e-008     nfactor=1
+ eta0=0.005                etab=-0.0097829           u0=0.04+du0n_3v
+ ua=-1.078386e-009         lua=-2.5995322e-017       ub=3.3816747e-018
+ lub=-3.6471049e-025       uc=2.1767052e-010         luc=-2.7650746e-017
+ vsat=70000+dvsatn_3v      a0=1.3695078              la0=-1.9399494e-007
+ ags=0.28819604            lags=2.2180089e-007       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=0.0065936222         lketa=-7.5514472e-008     dwg=0
+ dwb=0                     pclm=0.10650261           lpclm=-6.4664981e-008
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.30732202
+ lkt1=-4.6519988e-008      kt1l=0                    kt2=-0.068661673
+ lkt2=4.1385588e-008       ute=-1.3955183            lute=4.5265487e-007
+ ua1=1.8916447e-009        lua1=1.2684683e-015       ub1=-2.1560634e-018
+ lub1=-2.8775917e-025      uc1=-7.7881958e-011       luc1=2.865952e-017
+ prt=0                     at=166906.8               lat=-0.16812895
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     wvth0=0+dwvthn_3v         pvth0=0+dpvthn_3v
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ pvsat=0+dpvsatn_3v        pat=0+dpatn_3v            pcit=0+dpcitn_3v
+ fnoimod=1                 noia=noian_3v             noib=noibn_3v
+ noic=noicn_3v             em=3.00e7                 ef=0.951
+ minr=1e-3
 
 
 
     3: type=n 
+ lmin=5e-007-dxln_3v       lmax=1.2e-006-dxln_3v     wmin=1.003e-005-dxwn_3v
+ wmax=900.01e-6            version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.74090483+dvthn_3v  lvth0=-2.1800001e-009+dlvthn_3v
+ k1=0.88                   k2=0.0015612271+dk2n_3v   lk2=9.5455665e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=27.472               dvt1=0.45                 dvt2=0
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.16                 minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=1.83e-006           dvtp1=0.13                lpe0=8e-008
+ lpeb=2.1249e-009          xj=1.4e-007               ngate=9.7e+019
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00085644152         lcit=9.5629338e-011+dlcitn_3v
+ voff=-0.15553807          lvoff=-8.7200004e-010     nfactor=1
+ eta0=0.0030951714         leta0=2.1800001e-009      etab=-0.0097829
+ u0=0.034920457+du0n_3v    lu0=5.8133336e-009        ua=-1.0932267e-009
+ lua=-9.0106671e-018       ub=2.9125185e-018         lub=1.7222001e-025
+ uc=1.9098293e-010         luc=2.8921335e-018        vsat=70000+dvsatn_3v
+ a0=1.3904829              la0=-2.1800001e-007       ags=0.28008817
+ lags=2.3108001e-007       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.03677805
+ lketa=-2.5877328e-008     dwg=0                     dwb=0
+ pclm=0.018252857          lpclm=3.6333335e-008      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.32635655           lkt1=-2.4735735e-008
+ kt1l=0                    kt2=-0.0213885            lkt2=-1.2716667e-008
+ ute=-1                    ua1=3.3028043e-009        lua1=-3.4654735e-016
+ ub1=-3.0018065e-018       lub1=6.8016003e-025       uc1=-9.3144268e-011
+ luc1=4.6126622e-017       prt=0                     at=29524.143
+ lat=-0.010900001          jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3v                cjd=cjn_3v
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3v            cjswd=cjswn_3v
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3v          cjswgd=cjswgn_3v
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=3.73e-010         jtsswgd=3.73e-010
+ njtsswg=60                xtsswgs=0.836             xtsswgd=0.836
+ tnjtsswg=3                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     wvth0=0+dwvthn_3v
+ pvth0=0+dpvthn_3v         saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.45e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=1.00e-06             pku0=0.00e+00
+ kvth0=4.20e-09            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-5.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.30e-03             lk2we=2.00e-10
+ wk2we=2.00e-10            pvsat=0+dpvsatn_3v        pat=0+dpatn_3v
+ pcit=0+dpcitn_3v          fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
 
     4: type=n 
+ lmin=3.5e-007             lmax=5e-007-dxln_3v       wmin=1.003e-005-dxwn_3v
+ wmax=900.01e-6            version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.706554+dvthn_3v    lvth0=1.3087569e-008+dlvthn_3v
+ k1=0.88                   k2=-0.0008368168+dk2n_3v  lk2=1.0611401e-008
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=27.472               dvt1=0.45                 dvt2=0
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.16                 minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=1.83e-006           dvtp1=0.13                lpe0=8e-008
+ lpeb=2.1249e-009          xj=1.4e-007               ngate=9.7e+019
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0013809793          lcit=-1.3750673e-010+dlcitn_3v
+ voff=-0.15494801          lvoff=-1.134256e-009      nfactor=1
+ eta0=0.0040738667         leta0=1.7450092e-009      etab=0.046969554
+ letab=-2.5224196e-008     u0=0.0303324+du0n_3v      lu0=7.8525415e-009
+ ua=-1.6546979e-009        lua=2.405408e-016         ub=3.3490767e-018
+ lub=-2.1812615e-026       uc=3.3164598e-010         luc=-5.9626965e-017
+ vsat=70000+dvsatn_3v      a0=0.74295467             la0=6.9800369e-008
+ ags=2.1937773             lags=-6.1947827e-007      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.21010638          lketa=5.116018e-008       dwg=0
+ dwb=0                     pclm=-1.0974707           lpclm=5.3222781e-007
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.34194381
+ lkt1=-1.7807819e-008      kt1l=0                    kt2=-0.05
+ ute=-1                    ua1=4.6718028e-010        lua1=9.1377408e-016
+ ub1=6.9945543e-019        lub1=-9.6490285e-025      uc1=5.79685e-011
+ luc1=-2.1036959e-017      prt=0                     at=12852.267
+ lat=-0.0034900184         jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3v                cjd=cjn_3v
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3v            cjswd=cjswn_3v
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3v          cjswgd=cjswgn_3v
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=3.73e-010         jtsswgd=3.73e-010
+ njtsswg=60                xtsswgs=0.836             xtsswgd=0.836
+ tnjtsswg=3                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     wvth0=0+dwvthn_3v
+ pvth0=0+dpvthn_3v         pvsat=0+dpvsatn_3v        pat=0+dpatn_3v
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ pcit=0+dpcitn_3v          fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-dxln_3v       lmax=900.01e-6            wmin=1.23e-006-dxwn_3v
+ wmax=1.003e-005-dxwn_3v   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71965591+dvthn_3v  wvth0=1.3417791e-008+dwvthn_3v
+ k1=0.88                   k2=0.011787608+dk2n_3v    wk2=-1.1740567e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=27.472               dvt1=0.45                 dvt2=0
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.16                 minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=1.83e-006           dvtp1=0.13                lpe0=8e-008
+ lpeb=2.1249e-009          xj=1.4e-007               ngate=9.7e+019
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0010273523          wcit=-2.7305204e-010      voff=-0.14091236
+ wvoff=-1.2854244e-008     nfactor=1                 eta0=0.005
+ etab=-0.0097829           u0=0.04+du0n_3v           ua=-1.1259719e-009
+ wua=4.4894586e-016        ub=3.4175809e-018         wub=-7.245607e-025
+ uc=2.2063599e-010         wuc=-5.7361055e-017       vsat=70000+dvsatn_3v
+ a0=1.3634409              wa0=-1.3417791e-007       ags=0.31334947
+ wags=-2.8445716e-008      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.000759415
+ wketa=-1.7563888e-008     dwg=0                     dwb=0
+ pclm=0.046236364          wpclm=5.3671163e-007      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.31356452           wkt1=1.5618308e-008
+ kt1l=0                    kt2=-0.066448932          wkt2=1.9455797e-008
+ ute=-1.3701614            wute=2.0126686e-007       ua1=1.854401e-009
+ wua1=1.6451553e-015       ub1=-1.9980235e-018       wub1=-1.8665489e-024
+ uc1=-7.7978506e-011       wuc1=2.9733824e-017       prt=0
+ at=150000                 jss=3.05e-07              jsd=3.05e-07
+ jsws=3.54e-13             jswd=3.54e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3v                cjd=cjn_3v
+ mjs=0.325                 mjd=0.325                 pbsws=0.55
+ pbswd=0.55                cjsws=cjswn_3v            cjswd=cjswn_3v
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3v          cjswgd=cjswgn_3v
+ mjswgs=0.38               mjswgd=0.38               tpb=0.0017
+ tcj=0.000906              tpbsw=0.0016              tcjsw=0.00077
+ tpbswg=0.00115            tcjswg=0.000914           xtis=3
+ xtid=3                    jtsswgs=3.73e-010         jtsswgd=3.73e-010
+ njtsswg=60                xtsswgs=0.836             xtsswgd=0.836
+ tnjtsswg=3                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     lvth0=0+dlvthn_3v
+ pvth0=0+dpvthn_3v         pvsat=0+dpvsatn_3v        saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.45e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=1.00e-06
+ pku0=0.00e+00             kvth0=4.20e-09            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-5.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.30e-03
+ lk2we=2.00e-10            wk2we=2.00e-10            pat=0+dpatn_3v
+ lcit=0+dlcitn_3v          pcit=0+dpcitn_3v          fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     6: type=n 
+ lmin=1.2e-006-dxln_3v     lmax=1e-005-dxln_3v       wmin=1.23e-006-dxwn_3v
+ wmax=1.003e-005-dxwn_3v   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71713143+dvthn_3v  lvth0=2.5104621e-008+dlvthn_3v
+ wvth0=1.5250056e-008+dwvthn_3v                      pvth0=-1.8220885e-014+dpvthn_3v
+ k1=0.88                   k2=0.012025421+dk2n_3v    lk2=-2.3649245e-009
+ wk2=-1.2525998e-009       pk2=7.810686e-016         k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0010397614
+ lcit=-1.2340251e-010+dlcitn_3v                      wcit=-3.1903317e-010
+ pcit=4.5725745e-016+dpcitn_3v                       voff=-0.13919434
+ lvoff=-1.7084762e-008     wvoff=-1.1699044e-008     pvoff=-1.1487834e-014
+ nfactor=1                 eta0=0.005                etab=-0.0097829
+ u0=0.04001748+du0n_3v     lu0=-1.7383123e-010       wu0=-1.7450142e-010
+ pu0=1.7353224e-015        ua=-1.1251538e-009        lua=-8.1359022e-018
+ wua=4.6687414e-016        pua=-1.7828702e-022       ub=3.4582586e-018
+ lub=-4.0451785e-025       wub=-7.6452152e-025       pub=3.9738882e-031
+ uc=2.2380876e-010         luc=-3.1551519e-017       wuc=-6.1276867e-017
+ puc=3.8940634e-023        vsat=70000+dvsatn_3v      a0=1.3812007
+ la0=-1.7661182e-007       wa0=-1.1672777e-007       pa0=-1.7353224e-013
+ ags=0.29150349            lags=2.1724651e-007       wags=-3.3017654e-008
+ pags=4.5465446e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.0087730341
+ lketa=-7.9691115e-008     wketa=-2.1756634e-008     pketa=4.1694591e-014
+ dwg=0                     dwb=0                     pclm=0.047494915
+ lpclm=-1.2515613e-008     wpclm=5.8906205e-007      ppclm=-5.2059671e-013
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.30902236
+ lkt1=-4.5169319e-008      wkt1=1.6974184e-008       pkt1=-1.3483455e-014
+ kt1l=0                    kt2=-0.071169971          lkt2=4.6948187e-008
+ wkt2=2.5039842e-008       pkt2=-5.5530316e-014      ute=-1.4244198
+ lute=5.3957048e-007       wute=2.8851757e-007       pute=-8.6766119e-013
+ ua1=1.6893979e-009        lua1=1.6408669e-015       wua1=2.0189897e-015
+ pua1=-3.7175811e-021      ub1=-1.9480687e-018       lub1=-4.9677383e-025
+ wub1=-2.0763694e-024      pub1=2.0865516e-030       uc1=-8.1247825e-011
+ luc1=3.251162e-017        wuc1=3.3600776e-017       puc1=-3.8454744e-023
+ prt=0                     at=167256.4               lat=-0.17160558
+ wat=-0.0034900284         pat=3.4706447e-008+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     7: type=n 
+ lmin=5e-007-dxln_3v       lmax=1.2e-006-dxln_3v     wmin=1.23e-006-dxwn_3v
+ wmax=1.003e-005-dxwn_3v   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.74075868+dvthn_3v  lvth0=-1.9358236e-009+dlvthn_3v
+ wvth0=1.4589931e-009+dwvthn_3v                      pvth0=-2.4375654e-015+dpvthn_3v
+ k1=0.88                   k2=0.0025645168+dk2n_3v   lk2=8.4627022e-009
+ wk2=-1.001564e-008        pk2=1.0810018e-014        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00083799938
+ lcit=1.0750608e-010+dlcitn_3v                       wcit=1.8410423e-010
+ pcit=-1.1856318e-016+dpcitn_3v                      voff=-0.15324116
+ lvoff=-1.0087389e-009     wvoff=-2.2929555e-008     pvoff=1.3650366e-015
+ nfactor=1                 eta0=0.0028391452         leta0=2.4730119e-009
+ weta0=2.5558591e-009      peta0=-2.9250785e-015     etab=-0.0087773227
+ letab=-1.150843e-009      wetab=-1.0038478e-008     petab=1.1488636e-014
+ u0=0.034700706+du0n_3v    lu0=5.9110042e-009        wu0=2.1937321e-009
+ pu0=-9.7502617e-016       ua=-1.1107748e-009        lua=-2.459206e-017
+ wua=1.7517941e-016        pua=1.5554593e-022        ub=2.9202683e-018
+ lub=2.1119058e-025        wub=-7.7364029e-026       pub=-3.8903544e-031
+ uc=1.9345248e-010         luc=3.1900288e-018        wuc=-2.4653076e-017
+ puc=-2.9738298e-024       vsat=70000+dvsatn_3v      a0=1.4079771
+ la0=-2.0725624e-007       wa0=-1.7464098e-007       pa0=-1.0725288e-013
+ ags=0.30988325            lags=1.962116e-007        wags=-2.9743834e-007
+ pags=3.4808434e-013       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.039181469
+ lketa=-2.4809105e-008     wketa=2.3992848e-008      pketa=-1.0663861e-014
+ dwg=0                     dwb=0                     pclm=-0.0045756821
+ lpclm=4.7077102e-008      wpclm=2.2789274e-007      ppclm=-1.0725288e-013
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.32670944
+ lkt1=-2.4927169e-008      wkt1=3.5228571e-009       pkt1=1.9110513e-015
+ kt1l=0                    kt2=-0.017542854          lkt2=-1.4425903e-008
+ wkt2=-3.8390312e-008      pkt2=1.7062958e-014       ute=-0.9635307
+ lute=1.2101389e-008       wute=-3.6406569e-007      pute=-1.2080574e-013
+ ua1=3.4010641e-009        lua1=-3.180666e-016       wua1=-9.8090848e-016
+ pua1=-2.8431763e-022      ub1=-2.9040905e-018       lub1=5.9735489e-025
+ wub1=-9.754795e-025       pub1=8.2662719e-031       uc1=-9.8561528e-011
+ luc1=5.232646e-017        wuc1=5.4079423e-017       puc1=-6.1891736e-023
+ prt=0                     at=25129.119              lat=-0.0089465883
+ wat=0.043874642           pat=-1.9500524e-008+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     8: type=n 
+ lmin=3.5e-007             lmax=5e-007-dxln_3v       wmin=1.23e-006-dxwn_3v
+ wmax=1.003e-005-dxwn_3v   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.71078311+dvthn_3v  lvth0=1.1387117e-008+dlvthn_3v
+ wvth0=-4.2218363e-008+dwvthn_3v                     pvth0=1.6975272e-014+dpvthn_3v
+ k1=0.88                   k2=-0.0013363711+dk2n_3v  lk2=1.0196491e-008
+ wk2=4.9869502e-009        pk2=4.1419664e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0014308423
+ lcit=-1.5598888e-010+dlcitn_3v                      wcit=-4.9777227e-010
+ pcit=1.8450365e-016+dpcitn_3v                       voff=-0.15167115
+ lvoff=-1.7065461e-009     wvoff=-3.2712259e-008     pvoff=5.7130571e-015
+ nfactor=1                 eta0=0.005268656          leta0=1.3931916e-009
+ weta0=-1.1927343e-008     peta0=3.5121253e-015      etab=0.046977682
+ letab=-2.5931713e-008     wetab=-8.1147453e-011     petab=7.063001e-015
+ u0=0.029804692+du0n_3v    lu0=8.0870866e-009        wu0=5.2680035e-009
+ pu0=-2.3414169e-015       ua=-1.8669266e-009        lua=3.1148717e-016
+ wua=2.1186376e-015        pua=-7.0824348e-022       ub=3.614693e-018
+ lub=-9.7453411e-026       wub=-2.6515943e-024       pub=7.5510694e-031
+ uc=3.3997314e-010         luc=-6.1932544e-017       wuc=-8.3128434e-017
+ puc=2.3016128e-023        vsat=70000+dvsatn_3v      a0=0.92446411
+ la0=7.6459165e-009        wa0=-1.8119725e-006       pa0=6.2047547e-013
+ ags=2.3068638             lags=-6.9136635e-007      wags=-1.1289191e-006
+ pags=7.1764427e-013       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.22557772
+ lketa=5.8036574e-008      wketa=1.5444733e-007      pketa=-6.8645659e-014
+ dwg=0                     dwb=0                     pclm=-1.1488974
+ lpclm=5.5568232e-007      wpclm=5.1338256e-007      ppclm=-2.3414169e-013
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.35195967
+ lkt1=-1.3704453e-008      wkt1=9.9986294e-008       pkt1=-4.0963088e-014
+ kt1l=0                    kt2=-0.045514482          lkt2=-1.9936334e-009
+ wkt2=-4.477803e-008       pkt2=1.9902043e-014       ute=-0.96408736
+ lute=1.23488e-008         wute=-3.5850872e-007      pute=-1.232756e-013
+ ua1=3.8957075e-010        lua1=1.0204217e-015       wua1=7.7476045e-016
+ pua1=-1.0646422e-021      ub1=7.86171e-019          lub1=-1.0428187e-024
+ wub1=-8.6566419e-025      pub1=7.7781868e-031       uc1=9.1335381e-011
+ luc1=-3.207512e-017       wuc1=-3.3309489e-016      puc1=1.1019176e-022
+ prt=0                     at=15226.953              lat=-0.0045454714
+ wat=-0.023706016          pat=1.0536376e-008+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-dxln_3v       lmax=900.01e-6            wmin=5.3e-007-dxwn_3v
+ wmax=1.23e-006-dxwn_3v    version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.73272429+dvthn_3v  wvth0=-2.0394851e-009+dwvthn_3v
+ k1=0.88                   k2=0.013438813+dk2n_3v    wk2=-3.1271018e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=27.472               dvt1=0.45                 dvt2=0
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.16                 minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=1.83e-006           dvtp1=0.13                lpe0=8e-008
+ lpeb=2.1249e-009          xj=1.4e-007               ngate=9.7e+019
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.000794086           wcit=2.8552792e-012       voff=-0.15093855
+ wvoff=-9.9526875e-010     nfactor=1                 eta0=0.005
+ etab=-0.0097829           u0=0.04+du0n_3v           ua=-6.6254764e-010
+ wua=-9.9192399e-017       ub=2.7891366e-018         wub=1.8763263e-026
+ uc=1.7729906e-010         wuc=-6.1021396e-018       vsat=70000+dvsatn_3v
+ a0=1.1465429              wa0=1.2236911e-007        ags=0.28192006
+ wags=8.7289964e-009       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.010415202
+ wketa=-4.3465507e-009     dwg=0                     dwb=0
+ pclm=0.72760571           wpclm=-2.6921204e-007     pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.306395             wkt1=7.138198e-009
+ kt1l=0                    kt2=-0.05                 ute=-1.1199931
+ wute=-9.4632111e-008      ua1=3.8423167e-009        wua1=-7.0615134e-016
+ ub1=-4.0078611e-018       wub1=5.1068708e-025       uc1=-5.284e-011
+ prt=0                     at=150000                 jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3v
+ cjd=cjn_3v                mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3v
+ cjswd=cjswn_3v            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3v
+ cjswgd=cjswgn_3v          mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=3.73e-010
+ jtsswgd=3.73e-010         njtsswg=60                xtsswgs=0.836
+ xtsswgd=0.836             tnjtsswg=3                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3v         pvth0=0+dpvthn_3v         pvsat=0+dpvsatn_3v
+ pat=0+dpatn_3v            lcit=0+dlcitn_3v          saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.45e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=1.00e-06
+ pku0=0.00e+00             kvth0=4.20e-09            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-5.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.30e-03
+ lk2we=2.00e-10            wk2we=2.00e-10            pcit=0+dpcitn_3v
+ fnoimod=1                 noia=noian_3v             noib=noibn_3v
+ noic=noicn_3v             em=3.00e7                 ef=0.951
+ minr=1e-3
 
 
 
     10: type=n 
+ lmin=1.2e-006-dxln_3v     lmax=1e-005-dxln_3v       wmin=5.3e-007-dxwn_3v
+ wmax=1.23e-006-dxwn_3v    version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.73035856+dvthn_3v  lvth0=2.3525859e-008+dlvthn_3v
+ wvth0=-3.9499914e-010+dwvthn_3v                     pvth0=-1.6353525e-014+dpvthn_3v
+ k1=0.88                   k2=0.012450657+dk2n_3v    lk2=9.8266761e-009
+ wk2=-1.7555686e-009       pk2=-1.3639157e-014       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00074936663
+ lcit=4.4470994e-010+dlcitn_3v                       wcit=2.4445789e-011
+ pcit=-2.1470596e-016+dpcitn_3v                      voff=-0.14756933
+ lvoff=-3.3505063e-008     wvoff=-1.7931097e-009     pvoff=7.9340974e-015
+ nfactor=1                 eta0=0.0054484946         leta0=-4.4600361e-009
+ weta0=-5.3047936e-010     peta0=5.2753307e-015      etab=-0.0091106336
+ letab=-6.6853266e-009     wetab=-7.9515673e-010     petab=7.9074043e-015
+ u0=0.039869948+du0n_3v    lu0=1.2932996e-009        ua=-6.3754024e-010
+ lua=-2.4868513e-016       wua=-1.0987519e-016       pua=1.0623461e-022
+ ub=2.7834715e-018         lub=5.6336132e-026        wub=3.3616685e-026
+ pub=-1.4770926e-031       uc=1.7482096e-010         luc=2.4643366e-017
+ wuc=-3.3340983e-018       puc=-2.7526676e-023       vsat=70000+dvsatn_3v
+ a0=1.1656011              la0=-1.8952382e-007       wa0=1.3828349e-007
+ pa0=-1.5825992e-013       ags=0.25847811            lags=2.3311755e-007
+ wags=6.0447709e-009       pags=2.6693174e-014       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.0055340002        lketa=-4.8540919e-008     wketa=-4.8342735e-009
+ pketa=4.8501391e-015      dwg=0                     dwb=0
+ pclm=0.80003368           lpclm=-7.2025704e-007     wpclm=-3.010408e-007
+ ppclm=3.1651984e-013      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.30070651           lkt1=-5.6568926e-008      wkt1=7.138198e-009
+ pkt1=1.2744816e-028       kt1l=0                    kt2=-0.049237559
+ lkt2=-7.5820614e-009      wkt2=-9.0181491e-010      pkt2=8.9680623e-015
+ ute=-1.0766254            lute=-4.3126887e-007      wute=-1.2285361e-007
+ pute=2.806476e-013        ua1=4.0887044e-009        lua1=-2.4501928e-015
+ wua1=-8.1891003e-016      pua1=1.1213243e-021       ub1=-4.1866968e-018
+ lub1=1.7784244e-024       wub1=5.7148001e-025       pub1=-6.045529e-031
+ uc1=-5.284e-011           prt=0                     at=164216.05
+ lat=-0.14137095           wat=0.00010609587         pat=-1.0550662e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     11: type=n 
+ lmin=5e-007-dxln_3v       lmax=1.2e-006-dxln_3v     wmin=5.3e-007-dxwn_3v
+ wmax=1.23e-006-dxwn_3v    version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.75747255+dvthn_3v  lvth0=-7.5050137e-009+dlvthn_3v
+ wvth0=-1.8310171e-008+dwvthn_3v                     pvth0=4.1496726e-015+dpvthn_3v
+ k1=0.88                   k2=0.009931143+dk2n_3v    lk2=1.2710159e-008
+ wk2=-1.8728886e-008       pk2=5.7861257e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0011272141
+ lcit=1.2278591e-011+dlcitn_3v                       wcit=-1.5797899e-010
+ pcit=-5.9281038e-018+dpcitn_3v                      voff=-0.17981873
+ lvoff=3.403084e-009       wvoff=8.5063895e-009      pvoff=-3.8532675e-015
+ nfactor=1                 eta0=-0.00063821722       leta0=2.505962e-009
+ weta0=6.6688833e-009      peta0=-2.9640519e-015     etab=-0.029055015
+ letab=1.614022e-008       wetab=1.3945977e-008      petab=-8.9632336e-015
+ u0=0.034803683+du0n_3v    lu0=7.0914365e-009        wu0=2.0719304e-009
+ pu0=-2.3712415e-015       ua=-1.0180513e-009        lua=1.8679452e-016
+ wua=6.5505973e-017        pua=-9.4482118e-023       ub=2.8751231e-018
+ lub=-4.8555454e-026       wub=-2.3966305e-026       pub=-8.1807832e-032
+ uc=1.8668932e-010         luc=1.1060507e-017        wuc=-1.6653607e-017
+ puc=-1.2283031e-023       vsat=70000+dvsatn_3v      a0=1.17712
+ la0=-2.0270679e-007       wa0=9.8416696e-008        pa0=-1.1263397e-013
+ ags=0.33225154            lags=1.486868e-007        wags=-3.2389555e-007
+ pags=4.0429668e-013       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.018072373
+ lketa=-3.4191253e-008     wketa=-9.7499074e-010     pketa=4.3334439e-016
+ dwg=0                     dwb=0                     pclm=0.23944304
+ lpclm=-7.8683471e-008     wpclm=-6.0732604e-008     ppclm=4.1496726e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.33359791
+ lkt1=-1.8926034e-008      wkt1=1.1670546e-008       pkt1=-5.1870908e-015
+ kt1l=0                    kt2=-0.056081536          lkt2=2.505962e-010
+ wkt2=7.1932408e-009       pkt2=-2.9640519e-016      ute=-1.3713281
+ lute=-9.3993424e-008      wute=1.1827705e-007       pute=4.683202e-015
+ ua1=2.6434079e-009        lua1=-7.961088e-016       wua1=-8.4752765e-017
+ pua1=2.8111068e-022       ub1=-4.2603573e-018       lub1=1.8627258e-024
+ wub1=6.2871283e-025       pub1=-6.7005357e-031      uc1=-4.2195694e-011
+ luc1=-1.2181983e-017      wuc1=-1.2590085e-017      puc1=1.4408849e-023
+ prt=0                     at=65540.289              lat=-0.028440489
+ wat=-0.0039236897         pat=3.5568623e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     12: type=n 
+ lmin=3.5e-007             lmax=5e-007-dxln_3v       wmin=5.3e-007-dxwn_3v
+ wmax=1.23e-006-dxwn_3v    version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.7036627+dvthn_3v   lvth0=1.6411313e-008+dlvthn_3v
+ wvth0=-3.3796336e-008+dwvthn_3v                     pvth0=1.1032653e-014+dpvthn_3v
+ k1=0.88                   k2=0.015290002+dk2n_3v    lk2=1.0328361e-008
+ wk2=-1.4678724e-008       pk2=3.9859908e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0013173146
+ lcit=-7.2213467e-011+dlcitn_3v                      wcit=-3.6349173e-010
+ pcit=8.5414089e-017+dpcitn_3v                       voff=-0.19216073
+ lvoff=8.8886083e-009      wvoff=1.517881e-008       pvoff=-6.8188915e-015
+ nfactor=1                 eta0=-0.0048153333        leta0=4.3625231e-009
+ etab=0.060957079          letab=-2.3866555e-008     wetab=-1.6615978e-008
+ petab=4.6203328e-015      u0=0.038371346+du0n_3v    lu0=5.5057534e-009
+ wu0=-4.8646344e-009       pu0=7.1178408e-016        ua=6.9218223e-010
+ lua=-5.7333586e-016       wua=-9.0827643e-016       pua=3.3832521e-022
+ ub=5.4007924e-019         lub=9.8927814e-025        wub=9.8505882e-025
+ pub=-5.3027914e-031       uc=3.1609715e-010         luc=-4.6456097e-017
+ wuc=-5.4887909e-017       puc=4.710587e-024         vsat=70000+dvsatn_3v
+ a0=-0.93676969            la0=7.3683264e-007        wa0=3.8949489e-007
+ pa0=-2.4200659e-013       ags=1.448881              lags=-3.4761032e-007
+ wags=-1.1409707e-007      pags=3.1104964e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.095               dwg=0                     dwb=0
+ pclm=-0.85076232          lpclm=4.058692e-007       wpclm=1.6074841e-007
+ ppclm=-5.6942726e-014     pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=0.25
+ delta=0.01                pscbe1=1e+009             pscbe2=1e-010
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=240
+ rdw=240                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.17e+009           cgidl=24
+ egidl=0.65                aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3v              cgdo=cgon_3v
+ cgbo=0                    cgdl=cgln_3v              cgsl=cgln_3v
+ clc=1e-007                cle=0.6                   cf=cfn_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5                    noff=1.833                voffcv=-0.111
+ kt1=-0.09926488           lkt1=-1.2307769e-007      wkt1=-1.989011e-007
+ pkt1=8.8403582e-014       kt1l=0                    kt2=-0.090243803
+ lkt2=1.5434357e-008       wkt2=8.1278106e-009       pkt2=-7.1178408e-016
+ ute=-0.94106918           lute=-2.8522629e-007      wute=-3.8573461e-007
+ pute=2.2869622e-013       ua1=-3.8980847e-010       lua1=5.5203457e-016
+ wua1=1.6966102e-015       pua1=-5.106339e-022       ub1=3.284119e-018
+ lub1=-1.4904921e-024      wub1=-3.8202371e-024      pub1=1.3073267e-030
+ uc1=-2.6240382e-010       luc1=8.5691719e-017       wuc1=8.5307829e-017
+ puc1=-2.9102858e-023      prt=0                     at=-10971.815
+ lat=0.0055660808          wat=0.0072818865          pat=-1.4235682e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-dxln_3v       lmax=900.01e-6            wmin=2.2e-007
+ wmax=5.3e-007-dxwn_3v     version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.72989355+dvthn_3v  wvth0=-6.7280516e-010+dwvthn_3v
+ k1=0.88                   k2=0.02316141+dk2n_3v     wk2=-7.8211716e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=27.472               dvt1=0.45                 dvt2=0
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.16                 minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=1.83e-006           dvtp1=0.13                lpe0=8e-008
+ lpeb=2.1249e-009          xj=1.4e-007               ngate=9.7e+019
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00095734276         wcit=-7.5965085e-011      voff=-0.153
+ nfactor=1                 eta0=0.005                etab=-0.0097829
+ u0=0.039442581+du0n_3v    wu0=2.6912207e-010        ua=-8.8305032e-010
+ wua=7.2662957e-018        ub=2.9567639e-018         wub=-6.2167197e-026
+ uc=1.8180065e-010         wuc=-8.2755035e-018       vsat=70000+dvsatn_3v
+ a0=1.3163871              wa0=4.036831e-008         ags=0.29453729
+ wags=2.6373962e-009       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.02968455
+ wketa=4.9566902e-009      dwg=0                     dwb=0
+ pclm=0.11983226           wpclm=2.4220986e-008      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.30136484           wkt1=4.7096361e-009
+ kt1l=0                    kt2=-0.058082581          wkt2=3.9022699e-009
+ ute=-1.4364026            wute=5.8130366e-008       ua1=2.3400117e-009
+ wua1=1.9161491e-017       ub1=-2.9507132e-018       wub1=2.9603427e-028
+ uc1=-5.284e-011           prt=0                     at=150000
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3v         pvth0=0+dpvthn_3v
+ pvsat=0+dpvsatn_3v        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-4.45e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=1.00e-06             pku0=0.00e+00
+ kvth0=4.20e-09            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-5.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.30e-03             lk2we=2.00e-10
+ wk2we=2.00e-10            pat=0+dpatn_3v            lcit=0+dlcitn_3v
+ pcit=0+dpcitn_3v          fnoimod=1                 noia=noian_3v
+ noib=noibn_3v             noic=noicn_3v             em=3.00e7
+ ef=0.951                  minr=1e-3
 
 
     14: type=n 
+ lmin=1.2e-006-dxln_3v     lmax=1e-005-dxln_3v       wmin=2.2e-007
+ wmax=5.3e-007-dxwn_3v     version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.72933911+dvthn_3v  lvth0=5.5136283e-009+dlvthn_3v
+ wvth0=9.7193434e-011+dwvthn_3v                      pvth0=-7.6572202e-015+dpvthn_3v
+ k1=0.88                   k2=0.025593652+dk2n_3v    lk2=-2.4187335e-008
+ wk2=-8.1010066e-009       pk2=2.7828079e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00095734276
+ wcit=-7.5965085e-011      voff=-0.15161678          lvoff=-1.3755368e-008
+ wvoff=1.6099971e-010      pvoff=-1.6010551e-015     nfactor=1
+ eta0=0.0039872704         leta0=1.0071049e-008      weta0=1.7499968e-010
+ peta0=-1.7402773e-015     etab=-0.010772957         letab=9.8455815e-009
+ wetab=7.4129865e-012      petab=-7.3718148e-017     u0=0.039385022+du0n_3v
+ lu0=5.7238938e-010        wu0=2.3412213e-010        pu0=3.4805547e-016
+ ua=-8.9504174e-010        lua=1.1924815e-016        wua=1.4446533e-017
+ pua=-7.1403579e-023       ub=2.9883159e-018         lub=-3.1376784e-025
+ wub=-6.5282191e-026       pub=3.0976936e-032        uc=1.8507905e-010
+ luc=-3.2601981e-017       wuc=-8.2867035e-018       puc=1.1137775e-025
+ vsat=70000+dvsatn_3v      a0=1.3720327              la0=-5.5336536e-007
+ wa0=3.8618313e-008        pa0=1.7402773e-014        ags=0.27192957
+ lags=2.2482153e-007       wags=-4.4959814e-010      pags=3.0698492e-014
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.028957231         lketa=-7.2327907e-009
+ wketa=6.4744624e-009      pketa=-1.5093425e-014     dwg=0
+ dwb=0                     pclm=0.12705981           lpclm=-7.1874084e-008
+ wpclm=2.3870986e-008      ppclm=3.4805547e-015      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=0.25                 delta=0.01                pscbe1=1e+009
+ pscbe2=1e-010             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=240                   rdw=240                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.17e+009
+ cgidl=24                  egidl=0.65                aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3v
+ cgdo=cgon_3v              cgbo=0                    cgdl=cgln_3v
+ cgsl=cgln_3v              clc=1e-007                cle=0.6
+ cf=cfn_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5                    noff=1.833
+ voffcv=-0.111             kt1=-0.29567635           lkt1=-5.6568926e-008
+ wkt1=4.7096361e-009       pkt1=5.0435742e-030       kt1l=0
+ kt2=-0.060311677          lkt2=2.2167156e-008       wkt2=4.444769e-009
+ pkt2=-5.3948597e-015      ute=-1.4598979            lute=2.3364834e-007
+ wute=6.2190359e-008       pute=-4.0374434e-014      ua1=2.3450186e-009
+ lua1=-4.9790367e-017      wua1=2.2941484e-017       pua1=-3.758999e-023
+ ub1=-2.9985859e-018       lub1=4.7606826e-025       wub1=-2.1399613e-027
+ pub1=2.422466e-032        uc1=-5.284e-011           prt=0
+ at=164725.78              lat=-0.1464399            wat=-0.00013999975
+ pat=1.3922219e-009+dpatn_3v                         jss=3.05e-07
+ jsd=3.05e-07              jsws=3.54e-13             jswd=3.54e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3v
+ cjd=cjn_3v                mjs=0.325                 mjd=0.325
+ pbsws=0.55                pbswd=0.55                cjsws=cjswn_3v
+ cjswd=cjswn_3v            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3v
+ cjswgd=cjswgn_3v          mjswgs=0.38               mjswgd=0.38
+ tpb=0.0017                tcj=0.000906              tpbsw=0.0016
+ tcjsw=0.00077             tpbswg=0.00115            tcjswg=0.000914
+ xtis=3                    xtid=3                    jtsswgs=3.73e-010
+ jtsswgd=3.73e-010         njtsswg=60                xtsswgs=0.836
+ xtsswgd=0.836             tnjtsswg=3                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ pvsat=0+dpvsatn_3v        lcit=0+dlcitn_3v          saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-4.45e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=1.00e-06
+ pku0=0.00e+00             kvth0=4.20e-09            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-5.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.30e-03
+ lk2we=2.00e-10            wk2we=2.00e-10            pcit=0+dpcitn_3v
+ fnoimod=1                 noia=noian_3v             noib=noibn_3v
+ noic=noicn_3v             em=3.00e7                 ef=0.951
+ minr=1e-3
 
 
     15: type=n 
+ lmin=5e-007-dxln_3v       lmax=1.2e-006-dxln_3v     wmin=2.2e-007
+ wmax=5.3e-007-dxwn_3v     version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.72506398+dvthn_3v  lvth0=1.0406336e-008+dlvthn_3v
+ wvth0=-2.6633165e-009+dwvthn_3v                     pvth0=-4.497927e-015+dpvthn_3v
+ k1=0.88                   k2=-0.02374288+dk2n_3v    lk2=3.2276353e-008
+ wk2=-2.4710672e-009       pk2=-3.6604325e-015       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00098646054
+ lcit=-3.3324129e-011+dlcitn_3v                      wcit=-9.0023147e-011
+ pcit=1.6088889e-017+dpcitn_3v                       voff=-0.15889248
+ lvoff=-5.4286222e-009     wvoff=-1.5968035e-009     pvoff=4.1068029e-016
+ nfactor=1                 eta0=0.017731458          leta0=-5.6586239e-009
+ weta0=-2.199996e-009      peta0=9.7781022e-016      etab=0.0037841991
+ letab=-6.8145013e-009     wetab=-1.9087955e-009     petab=2.1193059e-015
+ u0=0.037272474+du0n_3v    lu0=2.9901163e-009        wu0=8.7999839e-010
+ pu0=-3.9112409e-016       ua=-9.6231526e-010        lua=1.9624e-016
+ wua=3.8596628e-017        pua=-9.9042397e-023       ub=3.0345285e-018
+ lub=-3.6665633e-025       wub=-1.0092724e-025       pub=7.177127e-032
+ uc=1.595033e-010          luc=-3.3315596e-018       wuc=-3.528198e-018
+ puc=-5.3345414e-024       vsat=70000+dvsatn_3v      a0=1.2694818
+ la0=-4.3600002e-007       wa0=5.3824413e-008        pa0=1.2737982e-028
+ ags=-0.12001103           lags=6.7338187e-007       wags=-1.0554318e-007
+ pags=1.509739e-013        a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.0026435952
+ lketa=-4.3398672e-008     wketa=-1.097666e-008      pketa=4.8786863e-015
+ dwg=0                     dwb=0                     pclm=0.089762285
+ lpclm=-2.9188561e-008     wpclm=1.1533265e-008      ppclm=1.7600584e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.32165763
+ lkt1=-2.6834395e-008      wkt1=5.9057761e-009       pkt1=-1.3689343e-015
+ kt1l=0                    kt2=-0.043102615          lkt2=2.4720732e-009
+ wkt2=9.2701786e-010       pkt2=-1.3689343e-015      ute=-1.1764257
+ lute=-9.0774267e-008      wute=2.4178172e-008       pute=3.1289927e-015
+ ua1=2.4321373e-009        lua1=-1.4949428e-016      wua1=1.7248684e-017
+ pua1=-3.1074809e-023      ub1=-2.8588044e-018       lub1=3.1609392e-025
+ wub1=-4.7956906e-026      pub1=7.6660321e-032       uc1=-5.7531871e-011
+ luc1=5.3696581e-018       wuc1=-5.1857792e-018      puc1=5.9349169e-024
+ prt=0                     at=58015.101              lat=-0.024313799
+ wat=-0.0002905288         pat=1.5644964e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
     16: type=n 
+ lmin=3.5e-007             lmax=5e-007-dxln_3v       wmin=2.2e-007
+ wmax=5.3e-007-dxwn_3v     version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3v              toxm=6.7e-009             dtox=5.58e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3v      xw=0+dxwn_3v
+ dlc=dlcn_3v               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.67162906+dvthn_3v  lvth0=3.4156022e-008+dlvthn_3v
+ wvth0=-1.8330496e-008+dwvthn_3v                     pvth0=2.4655075e-015+dpvthn_3v
+ k1=0.88                   k2=0.023240464+dk2n_3v    lk2=1.1394136e-008
+ wk2=-1.8517207e-008       pk2=3.4714346e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=27.472
+ dvt1=0.45                 dvt2=0                    dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.16
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=1.83e-006
+ dvtp1=0.13                lpe0=8e-008               lpeb=2.1249e-009
+ xj=1.4e-007               ngate=9.7e+019            ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00035827659
+ lcit=2.4587851e-010+dlcitn_3v                       wcit=9.9531833e-011
+ pcit=-6.8160717e-017+dpcitn_3v                      voff=-0.16636409
+ lvoff=-2.107791e-009      wvoff=2.7241931e-009      pvoff=-1.5098299e-015
+ nfactor=1                 eta0=-0.012475093         leta0=7.7669798e-009
+ weta0=3.6981319e-009      peta0=-1.6436717e-015     etab=0.009483205
+ letab=-9.3474814e-009     wetab=8.2356086e-009      petab=-2.389476e-015
+ u0=0.029389718+du0n_3v    lu0=6.4936859e-009        wu0=-5.2830455e-010
+ pu0=2.3481024e-016        ua=-7.8454146e-010        lua=1.1722666e-016
+ wua=-1.9531423e-016       pua=4.9216227e-024        ub=2.0730703e-018
+ lub=6.0673408e-026        wub=2.4493075e-025        pub=-8.1948775e-032
+ uc=2.1892042e-010         luc=-2.9740093e-017       wuc=-7.9709862e-018
+ puc=-3.3598998e-024       vsat=70000+dvsatn_3v      a0=0.66671675
+ la0=-1.6809505e-007       wa0=-3.8466837e-007       pa0=1.948925e-013
+ ags=0.45403966            lags=4.1823931e-007       wags=3.6621234e-007
+ pags=-5.8702561e-014      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.095
+ dwg=0                     dwb=0                     pclm=-0.2407337
+ lpclm=1.1770369e-007      wpclm=-1.337734e-007      ppclm=8.2183585e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=0.25                 delta=0.01
+ pscbe1=1e+009             pscbe2=1e-010             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=240                   rdw=240
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.17e+009           cgidl=24                  egidl=0.65
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3v              cgdo=cgon_3v              cgbo=0
+ cgdl=cgln_3v              cgsl=cgln_3v              clc=1e-007
+ cle=0.6                   cf=cfn_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5
+ noff=1.833                voffcv=-0.111             kt1=-0.56416658
+ lkt1=8.0951135e-008       wkt1=2.5553444e-008       pkt1=-1.0101537e-014
+ kt1l=0                    kt2=-0.086457734          lkt2=2.1741689e-008
+ wkt2=6.2998964e-009       pkt2=-3.7569639e-015      ute=-2.1679745
+ lute=3.4992951e-007       wute=2.0661527e-007       pute=-7.7957e-014
+ ua1=3.6436189e-009        lua1=-6.879494e-016       wua1=-2.5072857e-016
+ pua1=8.803036e-023        ub1=-5.7556437e-018       lub1=1.6036231e-024
+ wub1=5.4416037e-025       pub1=-1.8651212e-031      uc1=-2.5383028e-011
+ luc1=-8.9192166e-018      wuc1=-2.9125808e-017      puc1=1.6575302e-023
+ prt=0                     at=12741.287              lat=-0.0041913996
+ wat=-0.004166799          pat=3.2873434e-009+dpatn_3v
+ jss=3.05e-07              jsd=3.05e-07              jsws=3.54e-13
+ jswd=3.54e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3v                cjd=cjn_3v                mjs=0.325
+ mjd=0.325                 pbsws=0.55                pbswd=0.55
+ cjsws=cjswn_3v            cjswd=cjswn_3v            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3v          cjswgd=cjswgn_3v          mjswgs=0.38
+ mjswgd=0.38               tpb=0.0017                tcj=0.000906
+ tpbsw=0.0016              tcjsw=0.00077             tpbswg=0.00115
+ tcjswg=0.000914           xtis=3                    xtid=3
+ jtsswgs=3.73e-010         jtsswgd=3.73e-010         njtsswg=60
+ xtsswgs=0.836             xtsswgd=0.836             tnjtsswg=3
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-4.45e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=1.00e-06             pku0=0.00e+00             kvth0=4.20e-09
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-5.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.30e-03             lk2we=2.00e-10            wk2we=2.00e-10
+ xgl=0                     pvsat=0+dpvsatn_3v        fnoimod=1
+ noia=noian_3v             noib=noibn_3v             noic=noicn_3v
+ em=3.00e7                 ef=0.951                  minr=1e-3
 
 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V PMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
     } 
model pch3 bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_3v       lmax=0.00090001           wmin=1.003e-005-dxwp_3v
+ wmax=0.00090004           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71700001+dvthp_3v
+ k1=0.83978                k2=0.062000001+dk2p_3v    k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13                nfactor=1                 eta0=0.09
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0135+du0p_3v
+ ua=2.32e-009              ub=-2.64e-019             uc=-5.1750001e-011
+ vsat=80000+dvsatp_3v      a0=0.97242                ags=0.1495
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0096207           dwg=0
+ dwb=0                     pclm=0.15                 pdiblc1=0
+ pdiblc2=0.000145          pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.2913
+ kt1l=0                    kt2=-0.055                ute=-1.1
+ ua1=1.2499e-009           ub1=-2.8921e-018          uc1=-9.5535e-011
+ prt=0                     at=160000                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  lvth0=0+dlvthp_3v         wvth0=0+dwvthp_3v
+ pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     2: type=p 
+ lmin=1.2e-006-dxlp_3v     lmax=1e-005-dxlp_3v       wmin=1.003e-005-dxwp_3v
+ wmax=0.00090004           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71686717+dvthp_3v
+ lvth0=-1.3242778e-009+dlvthp_3v                     k1=0.83978
+ k2=0.06219262+dk2p_3v     lk2=-1.920222e-009        k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.12946864          lvoff=-5.2971641e-009     nfactor=1
+ eta0=0.09                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.0135+du0p_3v         ua=2.3027307e-009         lua=1.7215783e-016
+ ub=-2.7688557e-019        lub=1.2845623e-025        uc=-5.7349245e-011
+ luc=5.5818867e-017        vsat=80000+dvsatp_3v      a0=0.98614645
+ la0=-1.3683899e-007       ags=0.13668085            lags=1.2779408e-007
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0073146748        lketa=-2.2988765e-008
+ dwg=0                     dwb=0                     pclm=0.14468636
+ lpclm=5.2971641e-008      pdiblc1=0                 pdiblc2=0.00011976023
+ lpdiblc2=2.5161529e-010   pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.2913
+ kt1l=0                    kt2=-0.055265682          lkt2=2.648582e-009
+ ute=-1.1033874            lute=3.3769421e-008       ua1=1.2405613e-009
+ lua1=9.3097659e-017       ub1=-2.827805e-018        lub1=-6.4095686e-025
+ uc1=-9.4689468e-011       luc1=-8.4291124e-018      prt=0
+ at=168701.08              lat=-0.086741055          jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  wvth0=0+dwvthp_3v         pvth0=0+dpvthp_3v
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     3: type=p 
+ lmin=5e-007-dxlp_3v       lmax=1.2e-006-dxlp_3v     wmin=1.003e-005-dxwp_3v
+ wmax=0.00090004           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.708419+dvthp_3v
+ lvth0=-1.1200189e-008+dlvthp_3v                     k1=0.83978
+ k2=0.059578502+dk2p_3v    lk2=1.1356827e-009        k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13467             lvoff=7.8323e-010         nfactor=1
+ eta0=0.09                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.011825+du0p_3v       lu0=1.958075e-009         ua=2.26709e-009
+ lua=2.1382179e-016        ub=-7.3047e-019           lub=6.5869643e-025
+ uc=-7.9326902e-011        luc=8.1510748e-017        vsat=80000+dvsatp_3v
+ a0=0.9913717              la0=-1.4294731e-007       ags=0.03562
+ lags=2.4593422e-007       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.015620821
+ lketa=-1.3278881e-008     dwg=0                     dwb=0
+ pclm=0.22685              lpclm=-4.307765e-008      pdiblc1=0
+ pdiblc2=0.00045225        lpdiblc2=-1.3706525e-010  pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.2913               kt1l=0                    kt2=-0.05501
+ lkt2=2.34969e-009         ute=-1.010515             lute=-7.4798465e-008
+ ua1=1.388272e-009         lua1=-7.9576168e-017      ub1=-3.0017709e-018
+ lub1=-4.3759068e-025      uc1=-8.19876e-011         luc1=-2.3277596e-017
+ prt=0                     at=137879.83              lat=-0.050711017
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  wvth0=0+dwvthp_3v
+ pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     4: type=p 
+ lmin=3e-07                lmax=5e-007-dxlp_3v       wmin=1.003e-005-dxwp_3v
+ wmax=0.00090004           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.7246335+dvthp_3v
+ lvth0=-3.5955885e-009+dlvthp_3v                     k1=0.83978
+ k2=0.04855+dk2p_3v        lk2=6.30805e-009          k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13031             lvoff=-1.26161e-009       nfactor=1
+ eta0=0.09                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.0112925+du0p_3v      lu0=2.2078175e-009        ua=3.008409e-009
+ lua=-1.3385682e-016       ub=-1.10947e-018          lub=8.3644743e-025
+ uc=-1.3977518e-010        luc=1.0986099e-016        vsat=80000+dvsatp_3v
+ a0=1.2065301              la0=-2.4385659e-007       ags=0.0489
+ lags=2.397059e-007        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.015109303
+ lketa=-1.3518783e-008     dwg=0                     dwb=0
+ pclm=-0.006225            lpclm=6.6234525e-008      pdiblc1=0
+ pdiblc2=-2.83e-005        lpdiblc2=8.83127e-011     pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.1962354            lkt1=-4.4585297e-008      kt1l=0
+ kt2=-0.056725             lkt2=3.154025e-009        ute=-0.9215785
+ lute=-1.1650968e-007      ua1=-1.1034079e-009       lua1=1.0890217e-015
+ ub1=-1.1351826e-018       lub1=-1.3130206e-024      uc1=1.86972e-011
+ luc1=-7.0498767e-017      prt=0                     at=63048.119
+ lat=-0.015614944          jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1e-005              sbref=1e-005              wlod=5e-006
+ kvth0=-1.8e-009           lkvth0=-1e-011            wkvth0=4e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=6.38e-008             lku0=2.55e-007            wku0=1e-008
+ pku0=-2.5e-013            llodku0=1                 wlodku0=1
+ kvsat=-1                  steta0=-3e-010            tku0=0.5
+ wvth0=0+dwvthp_3v         pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     5: type=p 
+ lmin=1e-005-dxlp_3v       lmax=0.00090001           wmin=1.23e-006-dxwp_3v
+ wmax=1.003e-005-dxwp_3v   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71488065+dvthp_3v
+ wvth0=-2.1250845e-008+dwvthp_3v                     k1=0.83978
+ k2=0.060884547+dk2p_3v    wk2=1.1184661e-008        k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.12909369          wvoff=-9.0875385e-009     nfactor=1
+ eta0=0.092788636          weta0=-2.7961657e-008     etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013569716+du0p_3v    wu0=-6.9904142e-010
+ ua=2.3615507e-009         wua=-4.1662869e-016       ub=-2.7822205e-019
+ wub=1.4260445e-025        uc=-4.9657408e-011        wuc=-2.0982426e-017
+ vsat=80000+dvsatp_3v      a0=0.97625717             wa0=-3.8475296e-008
+ ags=0.15319494            wags=-3.7049195e-008      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.0095040932        wketa=-1.1692167e-009     dwg=0
+ dwb=0                     pclm=0.15                 pdiblc1=0
+ pdiblc2=0.00014249023     wpdiblc2=2.5165505e-011   pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.28886273           wkt1=-2.4438488e-008      kt1l=0
+ kt2=-0.055139432          wkt2=1.3980828e-009       ute=-1.0837144
+ wute=-1.6329608e-007      ua1=1.2089489e-009        wua1=4.1061693e-016
+ ub1=-2.768661e-018        wub1=-1.2377227e-024      uc1=-1.1017119e-010
+ wuc1=1.4675704e-016       prt=0                     at=160000
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  lvth0=0+dlvthp_3v         pvth0=0+dpvthp_3v
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     6: type=p 
+ lmin=1.2e-006-dxlp_3v     lmax=1e-005-dxlp_3v       wmin=1.23e-006-dxwp_3v
+ wmax=1.003e-005-dxwp_3v   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.71446627+dvthp_3v
+ lvth0=-4.1309302e-009+dlvthp_3v                     wvth0=-2.4073827e-008+dwvthp_3v
+ pvth0=2.8142304e-014+dpvthp_3v                      k1=0.83978
+ k2=0.061055865+dk2p_3v    lk2=-1.7078764e-009       wk2=1.1398242e-008
+ pk2=-2.1291888e-015       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1283308
+ lvoff=-7.6052679e-009     wvoff=-1.1409071e-008     pvoff=2.3143357e-014
+ nfactor=1                 eta0=0.092788636          weta0=-2.7961657e-008
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.013578977+du0p_3v
+ lu0=-9.2324153e-011       wu0=-7.9190272e-010       pu0=9.2573428e-016
+ ua=2.3523719e-009         lua=9.1503453e-017        wua=-4.9775232e-016
+ pua=8.0872147e-022        ub=-2.9812755e-019        lub=1.9843794e-025
+ wub=2.1299332e-025        pub=-7.017066e-031        uc=-5.5482383e-011
+ luc=5.8069176e-017        wuc=-1.8719025e-017       puc=-2.2563848e-023
+ vsat=80000+dvsatp_3v      a0=0.99049335             la0=-1.4192051e-007
+ wa0=-4.3586382e-008       pa0=5.0952415e-014        ags=0.14041284
+ lags=1.2742479e-007       wags=-3.742064e-008       pags=3.7029371e-015
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0071825778        lketa=-2.3143187e-008
+ wketa=-1.3245365e-009     pketa=1.5483832e-015      dwg=0
+ dwb=0                     pclm=0.14468636           lpclm=5.2971641e-008
+ pdiblc1=0                 pdiblc2=0.00011341635     lpdiblc2=2.8983749e-010
+ wpdiblc2=6.3610082e-011   ppdiblc2=-3.8325399e-016  pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.28832318           lkt1=-5.3788051e-009      wkt1=-2.9848587e-008
+ pkt1=5.3933279e-014       kt1l=0                    kt2=-0.055405114
+ lkt2=2.648582e-009        wkt2=1.3980828e-009       pkt2=-3.7537412e-029
+ ute=-1.085633             lute=1.912681e-008        wute=-1.7802388e-007
+ pute=1.4682146e-013       ua1=1.1904083e-009        lua1=1.8483094e-016
+ wua1=5.0288392e-016       pua1=-9.1980958e-022      ub1=-2.6903002e-018
+ lub1=-7.8117878e-025      wub1=-1.3787605e-024      pub1=1.4060052e-030
+ uc1=-1.1218049e-010       luc1=2.0030768e-017       wuc1=1.753825e-016
+ puc1=-2.8536722e-022      prt=0                     at=168710.34
+ lat=-0.086833378          wat=-9.2860183e-005       pat=9.2572317e-010
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          ngcon=1                   wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     7: type=p 
+ lmin=5e-007-dxlp_3v       lmax=1.2e-006-dxlp_3v     wmin=1.23e-006-dxwp_3v
+ wmax=1.003e-005-dxwp_3v   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.70843768+dvthp_3v
+ lvth0=-1.1178348e-008+dlvthp_3v                     wvth0=1.873431e-010+dwvthp_3v
+ pvth0=-2.1900408e-016+dpvthp_3v                     k1=0.83978
+ k2=0.058562671+dk2p_3v    lk2=1.2066673e-009        wk2=1.018573e-008
+ pk2=-7.1176218e-016       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.13531975
+ lvoff=5.6481563e-010      wvoff=6.515066e-009       pvoff=2.1900408e-015
+ nfactor=1                 eta0=0.092788636          weta0=-2.7961657e-008
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.011825+du0p_3v
+ lu0=1.958075e-009         ua=2.290934e-009          lua=1.6332439e-016
+ wua=-2.3908335e-016       pua=5.0633744e-022        ub=-7.6256581e-019
+ lub=7.4136627e-025        wub=3.2182466e-025        pub=-8.2893044e-031
+ uc=-7.3444704e-011        luc=7.9067128e-017        wuc=-5.8980808e-017
+ puc=2.4502176e-023        vsat=80000+dvsatp_3v      a0=0.98900166
+ la0=-1.4017673e-007       wa0=2.376437e-008         pa0=-2.7780613e-014
+ ags=0.024415956           lags=2.6302514e-007       wags=1.1234295e-007
+ pags=-1.713707e-013       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.016946534
+ lketa=-1.1729121e-008     wketa=1.3292932e-008      pketa=-1.5539437e-014
+ dwg=0                     dwb=0                     pclm=0.23946161
+ lpclm=-5.782062e-008      wpclm=-1.2645659e-007     ppclm=1.4782776e-013
+ pdiblc1=0                 pdiblc2=0.00051400853     lpdiblc2=-1.7845477e-010
+ wpdiblc2=-6.1925281e-010  ppdiblc2=4.1501273e-016   pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.29510105           lkt1=2.5445274e-009       wkt1=3.8113136e-008
+ pkt1=-2.5513976e-014      kt1l=0                    kt2=-0.055149432
+ lkt2=2.34969e-009         wkt2=1.3980828e-009       pkt2=2.0800544e-030
+ ute=-1.0081169            lute=-7.1489487e-008      wute=-2.4045627e-008
+ pute=-3.3179119e-014      ua1=1.4251478e-009        lua1=-8.9579546e-017
+ wua1=-3.6975377e-016      pua1=1.0030387e-022       ub1=-3.042043e-018
+ lub1=-3.6999143e-025      wub1=4.0380827e-025       pub1=-6.7781764e-031
+ uc1=-7.8896996e-011       luc1=-1.8877638e-017      wuc1=-3.0989485e-017
+ puc1=-4.4118373e-023      prt=0                     at=138276.84
+ lat=-0.051256616          wat=-0.0039808032         pat=5.4707286e-009
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          ngcon=1                   wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     8: type=p 
+ lmin=3e-07                lmax=5e-007-dxlp_3v       wmin=1.23e-006-dxwp_3v
+ wmax=1.003e-005-dxwp_3v   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72794375+dvthp_3v
+ lvth0=-2.0300022e-009+dlvthp_3v                     wvth0=3.3191885e-008+dwvthp_3v
+ pvth0=-1.5698134e-014+dpvthp_3v                     k1=0.83978
+ k2=0.044872486+dk2p_3v    lk2=7.6273643e-009        wk2=3.6874435e-008
+ pk2=-1.3228765e-014       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1348011
+ lvoff=3.2156719e-010      wvoff=4.5032248e-008      pvoff=-1.5874518e-014
+ nfactor=1                 eta0=0.092788636          weta0=-2.7961657e-008
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.010823661+du0p_3v
+ lu0=2.4277032e-009        wu0=4.7010536e-009        pu0=-2.2047941e-015
+ ua=3.1086115e-009         lua=-2.2016636e-016       wua=-1.0047301e-015
+ pua=8.6542579e-022        ub=-1.4455767e-018        lub=1.0616984e-024
+ wub=3.3701414e-024        pub=-2.258591e-030        uc=-1.5978864e-010
+ luc=1.1956244e-016        wuc=2.0067498e-016        puc=-9.727639e-023
+ vsat=80000+dvsatp_3v      a0=1.0460431              la0=-1.6692914e-007
+ wa0=1.6092035e-006        pa0=-7.7135154e-013       ags=0.12027096
+ lags=2.1806915e-007       wags=-7.1563666e-007      pags=2.1695174e-013
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.010567386         lketa=-1.4720942e-008
+ wketa=-4.5541802e-008     pketa=1.2054053e-014      dwg=0
+ dwb=0                     pclm=-0.059742418         lpclm=8.2506068e-008
+ wpclm=5.3661915e-007      ppclm=-1.6315476e-013     pdiblc1=0
+ pdiblc2=4.0851229e-005    lpdiblc2=4.3456004e-011   wpdiblc2=-6.9337937e-010
+ ppdiblc2=4.4977809e-016   pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.19113786
+ lkt1=-4.6214211e-008      wkt1=-5.111307e-008       pkt1=1.6333115e-014
+ kt1l=0                    kt2=-0.056676896          lkt2=3.0660708e-009
+ wkt2=-4.823367e-010       pkt2=8.8191676e-016       ute=-0.96409119
+ lute=-9.213755e-008       wute=4.2627476e-007       pute=-2.4437938e-013
+ ua1=-1.5257798e-009       lua1=1.2944055e-015       wua1=4.2351232e-015
+ pua1=-2.0593834e-021      ub1=-8.27956e-019         lub1=-1.4083982e-024
+ wub1=-3.0805611e-024      pub1=9.5635158e-031       uc1=2.887394e-011
+ luc1=-6.9422207e-017      wuc1=-1.0204217e-016      puc1=-1.0794663e-023
+ prt=0                     at=61251.105              lat=-0.015131547
+ wat=0.018018662           pat=-4.8470208e-009       jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1e-005              sbref=1e-005              wlod=5e-006
+ kvth0=-1.8e-009           lkvth0=-1e-011            wkvth0=4e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=6.38e-008             lku0=2.55e-007            wku0=1e-008
+ pku0=-2.5e-013            llodku0=1                 wlodku0=1
+ kvsat=-1                  steta0=-3e-010            tku0=0.5
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     9: type=p 
+ lmin=1e-005-dxlp_3v       lmax=0.00090001           wmin=5.3e-007-dxwp_3v
+ wmax=1.23e-006-dxwp_3v    version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72309043+dvthp_3v
+ wvth0=-1.1177444e-008+dwvthp_3v                     k1=0.83978
+ k2=0.067892+dk2p_3v       wk2=2.586516e-009         k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.13951143          wvoff=3.6950229e-009      nfactor=1
+ eta0=0.07                 etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.012247143+du0p_3v    wu0=9.2375571e-010        ua=1.8115011e-009
+ wua=2.582821e-016         ub=2.4906e-019            wub=-5.0437062e-025
+ uc=-2.7299251e-011        wuc=-4.8415885e-017       vsat=80000+dvsatp_3v
+ a0=0.98633722             wa0=-5.0843515e-008       ags=0.15175914
+ wags=-3.5287469e-008      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.013606051
+ wketa=3.8638856e-009      dwg=0                     dwb=0
+ pclm=0.11235714           wpclm=4.6187786e-008      pdiblc1=0
+ pdiblc2=0.00015998858     wpdiblc2=3.6950229e-012   pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.32193994           wkt1=1.6147241e-008       kt1l=0
+ kt2=-0.055505714          wkt2=1.8475114e-009       ute=-1.1485159
+ wute=-8.3784643e-008      ua1=2.2699264e-009        wua1=-8.9120252e-016
+ ub1=-4.7508443e-018       wub1=1.1944161e-024       uc1=7.904829e-011
+ wuc1=-8.5415258e-017      prt=0                     at=160000
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=1e-005              sbref=1e-005
+ wlod=5e-006               kvth0=-1.8e-009           lkvth0=-1e-011
+ wkvth0=4e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=6.38e-008             lku0=2.55e-007
+ wku0=1e-008               pku0=-2.5e-013            llodku0=1
+ wlodku0=1                 kvsat=-1                  steta0=-3e-010
+ tku0=0.5                  lvth0=0+dlvthp_3v         pvth0=0+dpvthp_3v
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
     10: type=p 
+ lmin=1.2e-006-dxlp_3v     lmax=1e-005-dxlp_3v       wmin=5.3e-007-dxwp_3v
+ wmax=1.23e-006-dxwp_3v    version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72785706+dvthp_3v
+ lvth0=4.7518589e-008+dlvthp_3v                      wvth0=-7.6433227e-009+dwvthp_3v
+ pvth0=-3.5231656e-014+dpvthp_3v                     k1=0.83978
+ k2=0.068267389+dk2p_3v    lk2=-3.7422572e-009       wk2=2.5497022e-009
+ pk2=3.6699642e-016        k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.14344086
+ lvoff=3.9172528e-008      wvoff=7.1309742e-009      pvoff=-3.4252999e-014
+ nfactor=1                 eta0=0.07                 etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.012130717+du0p_3v    lu0=1.1606465e-009
+ wu0=9.8511199e-010        pu0=-6.116607e-016        ua=1.6803612e-009
+ lua=1.307334e-015         wua=3.2680479e-016        pua=-6.8310267e-022
+ ub=3.4622724e-019         lub=-9.6866025e-025       wub=-5.7763001e-025
+ pub=7.3032288e-031        uc=-2.6684694e-011        luc=-6.126526e-018
+ wuc=-5.405379e-017        puc=5.6204278e-023        vsat=80000+dvsatp_3v
+ a0=1.0008703              la0=-1.4488073e-007       wa0=-5.6318948e-008
+ pa0=5.4584601e-014        ags=0.14199465            lags=9.73422e-008
+ wags=-3.9361526e-008      pags=4.0614272e-014       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.011829443         lketa=-1.7711001e-008     wketa=4.3771677e-009
+ pketa=-5.116909e-015      dwg=0                     dwb=0
+ pclm=0.1030431            lpclm=9.2851719e-008      wpclm=5.1096288e-008
+ ppclm=-4.8932856e-014     pdiblc1=0                 pdiblc2=0.00016554721
+ lpdiblc2=-5.5414012e-011  wpdiblc2=-3.5449126e-013  ppdiblc2=4.0369606e-017
+ pdiblcb=0                 drout=0.5                 pvag=1.2
+ delta=0.01                pscbe1=2.5e+008           pscbe2=3e-007
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14322
+ beta0=16.108              agidl=6.2e-010            bgidl=1.8206e+009
+ cgidl=60                  egidl=0.13                aigbacc=0.01095
+ bigbacc=0.00456           cigbacc=0.2247            nigbacc=4.046
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.005943
+ bigc=0.0006147            cigc=1e-010               aigsd=0.00452
+ bigsd=0                   cigsd=0.002267            nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_3v
+ cgdo=cgop_3v              cgbo=0                    cgdl=cglp_3v
+ cgsl=cglp_3v              clc=1e-007                cle=0.6
+ cf=cfp_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5.1                  noff=1.679
+ voffcv=-0.075642          kt1=-0.32872289           lkt1=6.7619255e-008
+ wkt1=1.9721856e-008       pkt1=-3.563534e-014       kt1l=0
+ kt2=-0.055771396          lkt2=2.648582e-009        wkt2=1.8475114e-009
+ pkt2=-2.2066341e-029      ute=-1.1217584            lute=-2.6674487e-007
+ wute=-1.3369798e-007      pute=4.97586e-013         ua1=2.599777e-009
+ lua1=-3.2882804e-015      wua1=-1.2264115e-015      pua1=3.3416981e-021
+ ub1=-4.9954399e-018       lub1=2.4383741e-024       wub1=1.449646e-024
+ pub1=-2.5443862e-030      uc1=1.0718684e-010        luc1=-2.8051316e-016
+ wuc1=-9.378121e-017       puc1=8.3400182e-023       prt=0
+ at=168434.64              lat=-0.084084914          wat=0.0002454251
+ pat=-2.4466428e-009       jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          ngcon=1
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     11: type=p 
+ lmin=5e-007-dxlp_3v       lmax=1.2e-006-dxlp_3v     wmin=5.3e-007-dxwp_3v
+ wmax=1.23e-006-dxwp_3v    version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.65615642+dvthp_3v
+ lvth0=-3.6299466e-008+dlvthp_3v                     wvth0=-6.3961769e-008+dwvthp_3v
+ pvth0=3.0604608e-014+dpvthp_3v                      k1=0.83978
+ k2=0.064126611+dk2p_3v    lk2=1.0983122e-009        wk2=3.3587758e-009
+ pk2=-5.7881055e-016       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.10765391
+ lvoff=-2.6624226e-009     wvoff=-2.7430926e-008     pvoff=6.1498621e-015
+ nfactor=1                 eta0=0.07                 etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.01069195+du0p_3v     lu0=2.8425655e-009
+ wu0=1.3902524e-009        pu0=-1.0852698e-015       ua=2.2921576e-009
+ lua=5.9214403e-016        wua=-2.4058479e-016       pua=-1.9824261e-023
+ ub=-8.478817e-019         lub=4.2725311e-025        wub=4.2650726e-025
+ pub=-4.4351359e-031       uc=-1.2453237e-010        luc=1.0825741e-016
+ wuc=3.703761e-018         puc=-1.1314299e-023       vsat=80000+dvsatp_3v
+ a0=0.98231765             la0=-1.2319264e-007       wa0=3.1965649e-008
+ pa0=-4.8620094e-014       ags=0.063244886           lags=1.8940068e-007
+ wags=6.469985e-008        pags=-8.1033477e-014      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.0074157514        lketa=-2.2870607e-008     wketa=1.5986609e-009
+ pketa=-1.8688346e-015     dwg=0                     dwb=0
+ pclm=0.113739             lpclm=8.0348209e-008      wpclm=2.7805047e-008
+ ppclm=-2.1705396e-014     pdiblc1=0                 pdiblc2=-2.2066598e-005
+ lpdiblc2=1.6390653e-010   wpdiblc2=3.8511376e-011   ppdiblc2=-5.0645923e-018
+ pdiblcb=0                 drout=0.5                 pvag=1.2
+ delta=0.01                pscbe1=2.5e+008           pscbe2=3e-007
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14322
+ beta0=16.108              agidl=6.2e-010            bgidl=1.8206e+009
+ cgidl=60                  egidl=0.13                aigbacc=0.01095
+ bigbacc=0.00456           cigbacc=0.2247            nigbacc=4.046
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.005943
+ bigc=0.0006147            cigc=1e-010               aigsd=0.00452
+ bigsd=0                   cigsd=0.002267            nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_3v
+ cgdo=cgop_3v              cgbo=0                    cgdl=cglp_3v
+ cgsl=cglp_3v              clc=1e-007                cle=0.6
+ cf=cfp_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5.1                  noff=1.679
+ voffcv=-0.075642          kt1=-0.24351536           lkt1=-3.1988344e-008
+ wkt1=-2.5182505e-008      pkt1=1.6857857e-014       kt1l=0
+ kt2=-0.056020129          lkt2=2.9393503e-009       wkt2=2.4664278e-009
+ pkt2=-7.2351319e-016      ute=-1.2905272            lute=-6.9454185e-008
+ wute=3.2247178e-007       pute=-3.5676435e-014      ua1=-6.3164448e-010
+ lua1=4.8925127e-016       wua1=2.1539304e-015       pua1=-6.0992155e-022
+ ub1=-1.5161789e-018       lub1=-1.6288821e-024      wub1=-1.468427e-024
+ pub1=8.6684115e-031       uc1=-1.0236075e-010       luc1=-3.5552035e-017
+ wuc1=-2.1994562e-018      puc1=-2.3658888e-023      prt=0
+ at=131367.97              lat=-0.040753977          wat=0.0044963809
+ pat=-7.4160102e-009       jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          ngcon=1
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
     12: type=p 
+ lmin=3e-07                lmax=5e-007-dxlp_3v       wmin=5.3e-007-dxwp_3v
+ wmax=1.23e-006-dxwp_3v    version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.69809865+dvthp_3v
+ lvth0=-1.662856e-008+dlvthp_3v                      wvth0=-3.4280575e-009+dwvthp_3v
+ pvth0=2.2142969e-015+dpvthp_3v                      k1=0.83978
+ k2=0.077750096+dk2p_3v    lk2=-5.2911022e-009       wk2=-3.4663933e-009
+ pk2=2.6221938e-015        k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.067697746
+ lvoff=-2.1401862e-008     wvoff=-3.7303565e-008     pvoff=1.078013e-014
+ nfactor=1                 eta0=0.07                 etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.017433043+du0p_3v    lu0=-3.190071e-010
+ wu0=-3.4086586e-009       pu0=1.1654194e-015        ua=2.508033e-009
+ lua=4.9089849e-016        wua=-2.6782034e-016       pua=-7.0507877e-024
+ ub=2.9362543e-018         lub=-1.3475067e-024       wub=-2.0063652e-024
+ pub=6.9750358e-031        uc=7.3874286e-011         luc=1.5204687e-017
+ wuc=-8.6029432e-017       puc=3.0770569e-023        vsat=80000+dvsatp_3v
+ a0=2.7983494              la0=-9.7491152e-007       wa0=-5.4087643e-007
+ pa0=2.2004284e-013        ags=-0.26147532           lags=3.4169446e-007
+ wags=-2.4723397e-007      pags=6.5263483e-014       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.057949996         lketa=8.2995411e-010      wketa=1.2596661e-008
+ pketa=-7.0268966e-015     dwg=0                     dwb=0
+ pclm=0.44328679           lpclm=-7.4209703e-008     wpclm=-8.0597686e-008
+ ppclm=2.9135486e-014      pdiblc1=0                 pdiblc2=-0.0013872878
+ lpdiblc2=8.041953e-010    wpdiblc2=1.0589473e-009   ppdiblc2=-4.8364903e-016
+ pdiblcb=0                 drout=0.5                 pvag=1.2
+ delta=0.01                pscbe1=2.5e+008           pscbe2=3e-007
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=100
+ rdw=100                   prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14322
+ beta0=16.108              agidl=6.2e-010            bgidl=1.8206e+009
+ cgidl=60                  egidl=0.13                aigbacc=0.01095
+ bigbacc=0.00456           cigbacc=0.2247            nigbacc=4.046
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.005943
+ bigc=0.0006147            cigc=1e-010               aigsd=0.00452
+ bigsd=0                   cigsd=0.002267            nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_3v
+ cgdo=cgop_3v              cgbo=0                    cgdl=cglp_3v
+ cgsl=cglp_3v              clc=1e-007                cle=0.6
+ cf=cfp_3v                 ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=5.1                  noff=1.679
+ voffcv=-0.075642          kt1=-0.20486922           lkt1=-5.0113384e-008
+ wkt1=-3.4264686e-008      pkt1=2.11174e-014         kt1l=0
+ kt2=-0.060860634          lkt2=5.2095475e-009       wkt2=4.65111e-009
+ pkt2=-1.7481292e-015      ute=-1.0933669            lute=-1.6192234e-007
+ wute=5.8489611e-007       pute=-1.5875345e-013      ua1=-1.2380198e-010
+ lua1=2.5107314e-016       wua1=2.5148964e-015       pua1=-7.7921462e-022
+ ub1=-2.9836109e-018       lub1=-9.4065644e-025      wub1=-4.3557253e-025
+ pub1=3.8243239e-031       uc1=1.1485528e-010        luc1=-1.3742636e-016
+ wuc1=-2.0754128e-016      puc1=7.2646427e-023       prt=0
+ at=97563.004              lat=-0.024899448          wat=-0.026536038
+ pat=7.1381941e-009        jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.53                 bvd=10.53
+ xjbvs=1                   xjbvd=1                   pbs=0.805
+ pbd=0.805                 cjs=cjp_3v                cjd=cjp_3v
+ mjs=0.395                 mjd=0.395                 pbsws=0.805
+ pbswd=0.805               cjsws=cjswp_3v            cjswd=cjswp_3v
+ mjsws=0.338               mjswd=0.338               pbswgs=0.805
+ pbswgd=0.805              cjswgs=cjswgp_3v          cjswgd=cjswgp_3v
+ mjswgs=0.4                mjswgd=0.4                tpb=0.00157
+ tcj=9.940197e-4           tpbsw=0.00157             tcjsw=0.000919
+ tpbswg=0.00157            tcjswg=0.000987           xtis=3
+ xtid=3                    jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=30                xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=14                vtsswgd=14
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          ngcon=1
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=-3.50e-03         pkvth0we=0.00e+00
+ wkvth0we=1.00e-11         lkvth0we=1.50e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=2.00e-03             lk2we=0.00e+00            wk2we=0.00e+00
+ fnoimod=1                 noia=noiap_3v             noib=noibp_3v
+ noic=noicp_3v             em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     13: type=p 
+ lmin=1e-005-dxlp_3v       lmax=0.00090001           wmin=2.2e-07
+ wmax=5.3e-007-dxwp_3v     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.74870999+dvthp_3v
+ wvth0=2.3240663e-009+dwvthp_3v                      k1=0.83978
+ k2=0.07805+dk2p_3v        wk2=-2.76675e-009         k3=-1.5
+ k3b=1                     w0=0                      dvt0=7.6
+ dvt1=0.34                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.31
+ minv=-0.3                 voffl=0                   dvtp0=1e-008
+ dvtp1=0.1                 lpe0=3e-008               lpeb=1e-009
+ xj=1.7e-007               ngate=6.32e+019           ndep=5.75e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0
+ voff=-0.12375             wvoff=-4.61125e-009       nfactor=1
+ eta0=0.077                weta0=-3.689e-009         etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.01435+du0p_3v        wu0=-1.8445e-010
+ ua=2.36215e-009           wua=-3.190985e-017        ub=-2.18e-019
+ wub=-2.5823e-025          uc=-6.2743e-011           wuc=-2.9737029e-017
+ vsat=80000+dvsatp_3v      a0=0.88985993             wa0=1.4756e-014
+ ags=0.095859998           wags=-5.8286196e-009      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.01180805          wketa=2.9163388e-009      dwg=0
+ dwb=0                     pclm=0.2                  pdiblc1=0
+ pdiblc2=-0.00010109998    wpdiblc2=1.412887e-010    pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.30149202           wkt1=5.3711877e-009       kt1l=0
+ kt2=-0.0534               wkt2=7.378e-010           ute=-1.36196
+ wute=2.870042e-008        ua1=4.7221611e-010        wua1=5.6190819e-017
+ ub1=-2.63987e-018         wub1=8.193269e-026        uc1=-1.296262e-010
+ wuc1=2.4556198e-017       prt=0                     at=160000
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  lvth0=0+dlvthp_3v
+ pvth0=0+dpvthp_3v         pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v
+ pcit=0+dpcitp_3v          wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     14: type=p 
+ lmin=1.2e-006-dxlp_3v     lmax=1e-005-dxlp_3v       wmin=2.2e-07
+ wmax=5.3e-007-dxwp_3v     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.744483+dvthp_3v
+ lvth0=-4.213894e-008+dlvthp_3v                      wvth0=1.118543e-009+dwvthp_3v
+ pvth0=1.2017862e-014+dpvthp_3v                      k1=0.83978
+ k2=0.078327638+dk2p_3v    lk2=-2.7677682e-009       wk2=-2.7520485e-009
+ pk2=-1.4655929e-016       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1195323
+ lvoff=-4.204624e-008      wvoff=-5.4688377e-009     pvoff=8.5492918e-015
+ nfactor=1                 eta0=0.077                weta0=-3.689e-009
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.01435+du0p_3v
+ wu0=-1.8445e-010          ua=2.3835467e-009         lua=-2.1330356e-016
+ wua=-4.3773963e-017       pua=1.1827335e-022        ub=-3.0643219e-019
+ lub=8.8158051e-025        wub=-2.3367849e-025       pub=-2.4475401e-031
+ uc=-7.541229e-011         luc=1.2630015e-016        wuc=-2.8374347e-017
+ puc=-1.358458e-023        vsat=80000+dvsatp_3v      a0=0.87557661
+ la0=1.4239042e-007        wa0=9.7108478e-009        pa0=-9.6807295e-014
+ ags=0.065560315           lags=3.0205755e-007       wags=9.1937068e-010
+ pags=-6.7270715e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.0091172174
+ lketa=-2.6824906e-008     wketa=2.9478245e-009      pketa=-3.1388095e-016
+ dwg=0                     dwb=0                     pclm=0.2
+ pdiblc1=0                 pdiblc2=-0.00012284604    lpdiblc2=2.1678643e-010
+ wpdiblc2=1.5162875e-010   ppdiblc2=-1.0308003e-016  pdiblcb=0
+ drout=0.5                 pvag=1.2                  delta=0.01
+ pscbe1=2.5e+008           pscbe2=3e-007             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=100                   rdw=100
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14322            beta0=16.108
+ agidl=6.2e-010            bgidl=1.8206e+009         cgidl=60
+ egidl=0.13                aigbacc=0.01095           bigbacc=0.00456
+ cigbacc=0.2247            nigbacc=4.046             aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.005943             bigc=0.0006147
+ cigc=1e-010               aigsd=0.00452             bigsd=0
+ cigsd=0.002267            nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_3v              cgdo=cgop_3v
+ cgbo=0                    cgdl=cglp_3v              cgsl=cglp_3v
+ clc=1e-007                cle=0.6                   cf=cfp_3v
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=5.1                  noff=1.679                voffcv=-0.075642
+ kt1=-0.29851173           lkt1=-2.9710447e-008      wkt1=3.8005776e-009
+ pkt1=1.5657412e-014       kt1l=0                    kt2=-0.053665682
+ lkt2=2.648582e-009        wkt2=7.378e-010           pkt2=-1.6560538e-030
+ ute=-1.4674961            lute=1.0520898e-006       wute=4.8505801e-008
+ pute=-1.9743985e-013      ua1=-1.1093802e-010       lua1=5.8134635e-015
+ wua1=2.0213534e-016       pua1=-1.454921e-021       ub1=-2.1595133e-018
+ lub1=-4.7886759e-024      wub1=-4.4887369e-026      pub1=1.2642692e-030
+ uc1=-1.0815282e-010       luc1=-2.1406807e-016      wuc1=1.970279e-017
+ puc1=4.8383618e-023       prt=0                     at=167250.72
+ lat=-0.072282452          wat=0.000869349           pat=-8.6665402e-009
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.53                 bvd=10.53                 xjbvs=1
+ xjbvd=1                   pbs=0.805                 pbd=0.805
+ cjs=cjp_3v                cjd=cjp_3v                mjs=0.395
+ mjd=0.395                 pbsws=0.805               pbswd=0.805
+ cjsws=cjswp_3v            cjswd=cjswp_3v            mjsws=0.338
+ mjswd=0.338               pbswgs=0.805              pbswgd=0.805
+ cjswgs=cjswgp_3v          cjswgd=cjswgp_3v          mjswgs=0.4
+ mjswgd=0.4                tpb=0.00157               tcj=9.940197e-4
+ tpbsw=0.00157             tcjsw=0.000919            tpbswg=0.00157
+ tcjswg=0.000987           xtis=3                    xtid=3
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=30
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=14                vtsswgd=14                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=-3.50e-03         pkvth0we=0.00e+00         wkvth0we=1.00e-11
+ lkvth0we=1.50e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=2.00e-03
+ lk2we=0.00e+00            wk2we=0.00e+00            fnoimod=1
+ noia=noiap_3v             noib=noibp_3v             noic=noicp_3v
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
     15: type=p 
+ lmin=5e-007-dxlp_3v       lmax=1.2e-006-dxlp_3v     wmin=2.2e-07
+ wmax=5.3e-007-dxwp_3v     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.80253279+dvthp_3v
+ lvth0=2.5721268e-008+dlvthp_3v                      wvth0=1.3178577e-008+dwvthp_3v
+ pvth0=-2.0803187e-015+dpvthp_3v                     k1=0.83978
+ k2=0.0737557+dk2p_3v      lk2=2.5768267e-009        wk2=-1.7157539e-009
+ pk2=-1.3579877e-015       k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.1578115
+ lvoff=2.7021435e-009      wvoff=-9.978745e-010      pvoff=3.3227358e-015
+ nfactor=1                 eta0=0.077                weta0=-3.689e-009
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0143835+du0p_3v
+ lu0=-3.9161501e-011       wu0=-5.551945e-010        pu0=4.3340032e-016
+ ua=1.9398336e-009         lua=3.0539699e-016        wua=-5.4910052e-017
+ pua=1.3129143e-022        ub=7.0035697e-019         lub=-2.9535602e-025
+ wub=-3.8941452e-025       pub=-6.2698583e-032       uc=-6.2567387e-011
+ luc=1.1128446e-016        wuc=-2.8951786e-017       puc=-1.2909554e-023
+ vsat=80000+dvsatp_3v      a0=1.2527249              la0=-2.9849597e-007
+ wa0=-1.1053899e-007       pa0=4.3764764e-014        ags=0.3738985
+ lags=-5.8389799e-008      wags=-9.9014607e-008      pags=4.9552105e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0093336119        lketa=-2.6571941e-008
+ wketa=2.6093733e-009      pketa=8.1768483e-017      dwg=0
+ dwb=0                     pclm=0.122883             lpclm=9.0149773e-008
+ wpclm=2.2986159e-008      ppclm=-2.687082e-014      pdiblc1=0
+ pdiblc2=-0.00028137796    lpdiblc2=4.0211025e-010   wpdiblc2=1.7516847e-010
+ ppdiblc2=-1.3059795e-016  pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.29355925
+ lkt1=-3.54999e-008        wkt1=1.1906248e-009       pkt1=1.8708447e-014
+ kt1l=0                    kt2=-0.051333             lkt2=-7.8323002e-011
+ wkt2=-3.689e-012          pkt2=8.6680064e-016       ute=-0.36242656
+ lute=-2.3973658e-007      wute=-1.6663725e-007      pute=5.4062385e-014
+ ua1=5.9153443e-009        lua1=-1.2312605e-015      wua1=-1.2963327e-015
+ pua1=2.9678817e-022       ub1=-6.4159425e-018       lub1=1.8708985e-025
+ wub1=1.1137484e-024       pub1=-9.0176045e-032      uc1=-2.4967621e-010
+ luc1=-4.8627239e-017      wuc1=7.5435788e-017       puc1=-1.6768256e-023
+ prt=0                     at=156886.06              lat=-0.060166167
+ wat=-0.0089516554         pat=2.8142139e-009        jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1e-005              sbref=1e-005              wlod=5e-006
+ kvth0=-1.8e-009           lkvth0=-1e-011            wkvth0=4e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=6.38e-008             lku0=2.55e-007            wku0=1e-008
+ pku0=-2.5e-013            llodku0=1                 wlodku0=1
+ kvsat=-1                  steta0=-3e-010            tku0=0.5
+ pvsat=0+dpvsatp_3v        lcit=0+dlcitp_3v          pcit=0+dpcitp_3v
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     16: type=p 
+ lmin=3e-07                lmax=5e-007-dxlp_3v       wmin=2.2e-07
+ wmax=5.3e-007-dxwp_3v     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_3v              toxm=6.794e-009           dtox=5.93e-010
+ epsrox=3.9                wint=1.4999999e-009       lint=8e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_3v       xw=0+dxwp_3v
+ dlc=dlcp_3v               dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.72317065+dvthp_3v
+ lvth0=-1.1499575e-008+dlvthp_3v                     wvth0=9.7848881e-009+dwvthp_3v
+ pvth0=-4.8867833e-016+dpvthp_3v                     k1=0.83978
+ k2=0.09150295+dk2p_3v     lk2=-5.7466336e-009       wk2=-1.0714147e-008
+ pk2=2.8622588e-015        k3=-1.5                   k3b=1
+ w0=0                      dvt0=7.6                  dvt1=0.34
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.31                 minv=-0.3
+ voffl=0                   dvtp0=1e-008              dvtp1=0.1
+ lpe0=3e-008               lpeb=1e-009               xj=1.7e-007
+ ngate=6.32e+019           ndep=5.75e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.16368425
+ lvoff=5.4564633e-009      wvoff=1.3281322e-008      pvoff=-3.3742075e-015
+ nfactor=1                 eta0=0.077                weta0=-3.689e-009
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0112065+du0p_3v
+ lu0=1.4508515e-009        wu0=-1.272705e-010        pu0=2.3270396e-016
+ ua=8.5993122e-010         lua=8.1187122e-016        wua=6.0072929e-016
+ pua=-1.7620342e-022       ub=1.6111628e-018         lub=-7.2252396e-025
+ wub=-1.3080419e-024       pub=3.6813768e-031        uc=2.1025018e-011
+ luc=7.2079621e-017        wuc=-5.8177868e-017       puc=7.9747858e-025
+ vsat=80000+dvsatp_3v      a0=2.6408098              la0=-9.4950776e-007
+ wa0=-4.5785304e-007       pa0=2.0665506e-013        ags=-0.50501048
+ lags=3.5381851e-007       wags=-1.1889094e-007      pags=5.8874105e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.046434175         lketa=-9.1717764e-009
+ wketa=6.5278234e-009      pketa=-1.7559846e-015     dwg=0
+ dwb=0                     pclm=0.7725345            lpclm=-2.1453678e-007
+ wpclm=-2.5411123e-007     ppclm=1.0308786e-013      pdiblc1=0
+ pdiblc2=0.0011099645      lpdiblc2=-2.5042937e-010  wpdiblc2=-2.5710472e-010
+ ppdiblc2=7.2138173e-017   pdiblcb=0                 drout=0.5
+ pvag=1.2                  delta=0.01                pscbe1=2.5e+008
+ pscbe2=3e-007             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=100                   rdw=100                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14322            beta0=16.108              agidl=6.2e-010
+ bgidl=1.8206e+009         cgidl=60                  egidl=0.13
+ aigbacc=0.01095           bigbacc=0.00456           cigbacc=0.2247
+ nigbacc=4.046             aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.005943             bigc=0.0006147            cigc=1e-010
+ aigsd=0.00452             bigsd=0                   cigsd=0.002267
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_3v              cgdo=cgop_3v              cgbo=0
+ cgdl=cglp_3v              cgsl=cglp_3v              clc=1e-007
+ cle=0.6                   cf=cfp_3v                 ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=5.1
+ noff=1.679                voffcv=-0.075642          kt1=-0.47452786
+ lkt1=4.9374378e-008       wkt1=1.0784542e-007       pkt1=-3.131265e-014
+ kt1l=0                    kt2=-0.055534998          lkt2=1.8924139e-009
+ wkt2=1.8444995e-009       pkt2=2.3270396e-022       ute=0.61497069
+ lute=-6.9813589e-007      wute=-3.1539782e-007      pute=1.2383109e-013
+ ua1=8.8879497e-009        lua1=-2.6254125e-015      wua1=-2.2342967e-015
+ pua1=7.3669329e-022       ub1=-8.4397388e-018       lub1=1.1362503e-024
+ wub1=2.4398069e-024       pub1=-7.1209747e-031      uc1=-4.6003775e-010
+ luc1=5.0032324e-017       wuc1=9.5427347e-017       puc1=-2.6144297e-023
+ prt=0                     at=60341.988              lat=-0.014886995
+ wat=-0.0069205623         pat=1.8616313e-009        jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.53
+ bvd=10.53                 xjbvs=1                   xjbvd=1
+ pbs=0.805                 pbd=0.805                 cjs=cjp_3v
+ cjd=cjp_3v                mjs=0.395                 mjd=0.395
+ pbsws=0.805               pbswd=0.805               cjsws=cjswp_3v
+ cjswd=cjswp_3v            mjsws=0.338               mjswd=0.338
+ pbswgs=0.805              pbswgd=0.805              cjswgs=cjswgp_3v
+ cjswgd=cjswgp_3v          mjswgs=0.4                mjswgd=0.4
+ tpb=0.00157               tcj=9.940197e-4           tpbsw=0.00157
+ tcjsw=0.000919            tpbswg=0.00157            tcjswg=0.000987
+ xtis=3                    xtid=3                    jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=30                xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=14
+ vtsswgd=14                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1e-005
+ sbref=1e-005              wlod=5e-006               kvth0=-1.8e-009
+ lkvth0=-1e-011            wkvth0=4e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=6.38e-008
+ lku0=2.55e-007            wku0=1e-008               pku0=-2.5e-013
+ llodku0=1                 wlodku0=1                 kvsat=-1
+ steta0=-3e-010            tku0=0.5                  pvsat=0+dpvsatp_3v
+ lcit=0+dlcitp_3v          pcit=0+dpcitp_3v          rbsb=50
+ ngcon=1                   wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=-3.50e-03
+ pkvth0we=0.00e+00         wkvth0we=1.00e-11         lkvth0we=1.50e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=2.00e-03             lk2we=0.00e+00
+ wk2we=0.00e+00            fnoimod=1                 noia=noiap_3v
+ noib=noibp_3v             noic=noicp_3v             em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     } 
endsection mos_3v
 
 
// *********************************************************************************************
 

section mos_m
// *********************************************************************************************
 
// *********************************************************************************************
//                                                                            
//                   *
//                               1.8 V MED-SVT  NMOS DEVICE MODELS            
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt mench_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 xw= + 0 
+ + dxwnm ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg 
+ + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + 
+ (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) 
+ * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_m 
+ temp1=parn1m temp2=parn2m fac1=0.639217 * temp1 * sigma + 0.769027 * temp2 * sigma 
+ fac2=0.639217 * temp1 * sigma - 0.769027 * temp2 * sigma lef=l * factor - 1.5e-08 
+ wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) vthmisnm=0.00220296 
+ * geo_fac * fac1 * mismatchflag dlmisnm=0.00162770 * geo_fac * lef * fac2 * mismatchflag 
+ dwmisnm= - 0.00162770 * geo_fac * wef * fac2 * mismatchflag toxmisnm=0.00162770 
+ * geo_fac * toxnm * fac2 * mismatchflag 
mench_mac ( n1 n2 n3 n4 ) mench w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model mench bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxlnm+dlmisnm)                         lmax=2.001e-05
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.276+(dvthnm+vthmisnm)                        k1=0.4215
+ k2=0.021275+dk2m          k3=-2.2                   k3b=1.2
+ w0=0                      dvt0=0.2843               dvt1=0.1496
+ dvt2=-0.2039              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.684                minv=-0.112
+ voffl=-2.2e-009           dvtp0=0                   dvtp1=0
+ lpe0=9.17e-008            lpeb=0                    web=0
+ wec=0                     scref=1e-006              kvth0we=0.0024984743
+ lkvth0we=0                wkvth0we=0                pkvth0we=0
+ k2we=0.0043               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.5e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0004+dcitnm        voff=-0.089+dvoffnm       nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-8.807e-010
+ ub=3.208e-018             uc=1.918e-010             vsat=88560+dvsatnm
+ a0=1.806+da0nm            ags=0.66052               a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0674              dwg=0                     dwb=0
+ pclm=0.8351+dpclmnm       pdiblc1=0                 pdiblc2=0.000776+dpdiblc2nm
+ pdiblcb=0.55              drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.20623
+ kt1l=0                    kt2=-0.039870001          ute=-1.7599
+ ua1=5.3952e-010           ub1=-5.1533001e-019       uc1=-2.8145e-010
+ prt=0                     at=30388                  jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 lvth0=0+dlvthnm
+ wvth0=0+dwvthnm           pvth0=0+dpvthnm           lk2=0+dlk2m
+ lcit=0+dlcitnm            pcit=0+dpcitnm            lvoff=0+dlvoffnm
+ pvoff=0+dpvoffnm          lu0=0+dlu0nm              pu0=0+dpu0nm
+ lvsat=0+dlvsatnm          pvsat=0+dpvsatnm          la0=0+dla0nm
+ pa0=0+dpa0nm              lpclm=0+dlpclmnm          ppclm=0+dppclmnm
+ lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     2: type=n 
+ lmin=1.2e-006-(dxlnm+dlmisnm)                       lmax=1e-005-(dxlnm+dlmisnm)
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27419524+(dvthnm+vthmisnm)                   lvth0=1.7929235e-008+dlvthnm
+ k1=0.4215                 k2=0.021898286+dk2m       lk2=-6.1919893e-009+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025032258      lkvth0we=-4.7203705e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037421773+dcitnm
+ lcit=-2.5613193e-010+dlcitnm                        voff=-0.087710886+dvoffnm
+ lvoff=-1.2806596e-008+dlvoffnm                      nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-8.6739635e-010
+ lua=-1.3216407e-016       ub=3.1904552e-018         lub=1.7429778e-025
+ uc=1.918e-010             vsat=86543.826+dvsatnm    lvsat=0.020029517+dlvsatnm
+ a0=1.8640101+da0nm        la0=-5.7629683e-007+dla0nm
+ ags=0.64714416            lags=1.3288124e-007       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.066342927         lketa=-1.0501409e-008     dwg=0
+ dwb=0                     pclm=0.83712391+dpclmnm   lpclm=-2.0106356e-008+dlpclmnm
+ pdiblc1=0                 pdiblc2=0.00050956599+dpdiblc2nm
+ lpdiblc2=2.6468673e-009+dlpdiblc2nm                 pdiblcb=0.56289114
+ lpdiblcb=-1.2806595e-007  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.20141258
+ lkt1=-4.785825e-008       kt1l=0                    kt2=-0.039432992
+ lkt2=-4.3414349e-009      ute=-1.7475632            lute=-1.2255913e-007
+ ua1=4.7832835e-010        lua1=6.0790351e-016       ub1=-3.5875814e-019
+ lub1=-1.5554508e-024      uc1=-3.1257565e-010       luc1=3.0921527e-016
+ prt=0                     at=30388                  jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 wvth0=0+dwvthnm
+ pvth0=0+dpvthnm           pcit=0+dpcitnm            pvoff=0+dpvoffnm
+ lu0=0+dlu0nm              pu0=0+dpu0nm              pvsat=0+dpvsatnm
+ pa0=0+dpa0nm              ppclm=0+dppclmnm          ppdiblc2=0+dppdiblc2nm
+ leta0=0+dleta0nm          peta0=0+dpeta0nm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noian_m
+ noib=noibn_m              noic=noicn_m              em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=5e-007-(dxlnm+dlmisnm)                         lmax=1.2e-006-(dxlnm+dlmisnm)
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.2924824+(dvthnm+vthmisnm)                    lvth0=-2.8160842e-009+dlvthnm
+ k1=0.4215                 k2=0.016713064+dk2m       lk2=-3.0976926e-010+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025032258      lkvth0we=-4.7203626e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00078618+dcitnm
+ lcit=2.1120632e-010+dlcitnm                         voff=-0.10244433+dvoffnm
+ lvoff=3.9073168e-009+dlvoffnm                       nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-9.981738e-010
+ lua=1.6192484e-017        ub=3.2418872e-018         lub=1.1595227e-025
+ uc=1.8081538e-010         luc=1.2461173e-017        vsat=108358.02+dvsatnm
+ lvsat=-0.004716941+dlvsatnm                         a0=1.2653924+da0nm
+ la0=1.0278707e-007+dla0nm ags=0.90166843            lags=-1.5585618e-007
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.08466076          lketa=1.0278707e-008
+ dwg=0                     dwb=0                     pclm=0.73180852+dpclmnm
+ lpclm=9.9365531e-008+dlpclmnm                       pdiblc1=0
+ pdiblc2=0.0021294203+dpdiblc2nm                     lpdiblc2=8.092722e-010+dlpdiblc2nm
+ pdiblcb=0.79133002        lpdiblcb=-3.8721159e-007  drout=0.5
+ pvag=1.787                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=78.59                 rdw=78.59
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=1e-008              bgidl=2.2849e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgonm                cgdo=cgonm
+ cgbo=0                    cgdl=cglnm                cgsl=cglnm
+ clc=1e-007                cle=0.6                   cf=cfnm
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=1.586                voffcv=0.0135
+ kt1=-0.23664928           lkt1=-7.8850358e-009      kt1l=0
+ kt2=-0.047715908          lkt2=5.0548712e-009       ute=-1.82246
+ lute=-3.7594724e-008      ua1=1.0168065e-009        lua1=-2.9568884e-018
+ ub1=-1.7298379e-018       lub1=-7.0402105e-029      uc1=-3.672323e-011
+ luc1=-3.7172319e-018      prt=0                     at=30299.875
+ lat=9.9970989e-005        jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 wvth0=0+dwvthnm           pvth0=0+dpvthnm
+ pcit=0+dpcitnm            pvoff=0+dpvoffnm          lu0=0+dlu0nm
+ pu0=0+dpu0nm              pvsat=0+dpvsatnm          pa0=0+dpa0nm
+ ppclm=0+dppclmnm          ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     4: type=n 
+ lmin=2.85e-07             lmax=5e-007-(dxlnm+dlmisnm)
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.2918605+(dvthnm+vthmisnm)                    lvth0=-2.5459184e-009+dlvthnm
+ k1=0.4215                 k2=0.0034597021+dk2m      lk2=5.4477562e-009+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025193604      lkvth0we=-5.4212838e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0003+dcitnm
+ voff=-0.10072991+dvoffnm  lvoff=3.1625398e-009+dlvoffnm
+ nfactor=1                 eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.041282261+du0nm
+ lu0=-6.9605409e-010+dlu0nm                          ua=-1.1847477e-009
+ lua=9.72439e-017          ub=4.3774433e-018         lub=-3.7735603e-025
+ uc=2.294257e-010          luc=-8.6561226e-018       vsat=114367.69+dvsatnm
+ lvsat=-0.0073276624+dlvsatnm                        a0=1.8412057+da0nm
+ la0=-1.4735776e-007+dla0nm                          ags=0.82232864
+ lags=-1.2138939e-007      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.082808093
+ lketa=9.4738716e-009      dwg=0                     dwb=0
+ pclm=0.76050941+dpclmnm   lpclm=8.6897287e-008+dlpclmnm
+ pdiblc1=0                 pdiblc2=0.00059637467+dpdiblc2nm
+ lpdiblc2=1.4752579e-009+dlpdiblc2nm                 pdiblcb=0.034614419
+ lpdiblcb=-5.8479196e-008  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.2752614
+ lkt1=8.8888399e-009       kt1l=0                    kt2=-0.041356886
+ lkt2=2.2923847e-009       ute=-2.2980357            lute=1.6900489e-007
+ ua1=-1.1699197e-010       lua1=4.8958785e-016       ub1=-3.9274033e-019
+ lub1=-5.8093235e-025      uc1=-4.6572299e-011       luc1=5.6140047e-019
+ prt=0                     at=31243.456              lat=-0.0003099396
+ jss=2.34e-07              jsd=2.34e-07              jsws=7.68e-13
+ jswd=7.68e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.3                  bvd=11.3                  xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjnm                  cjd=cjnm                  mjs=0.333
+ mjd=0.333                 pbsws=0.29                pbswd=0.29
+ cjsws=cjswnm              cjswd=cjswnm              mjsws=0.146
+ mjswd=0.146               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgnm            cjswgd=cjswgnm            mjswgs=0.713
+ mjswgd=0.713              tpb=0.00149               tcj=0.000913
+ tpbsw=0.001               tcjsw=0.000765            tpbswg=0.00115
+ tcjswg=0.00083            xtis=3                    xtid=3
+ jtsswgs=3.9893e-010       jtsswgd=3.9893e-010       njtsswg=17.974
+ xtsswgs=0.30393           xtsswgd=0.30393           tnjtsswg=0
+ vtsswgs=11.126            vtsswgd=11.126            dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-4e-008               lku0=2e-007               wku0=2e-006
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ wvth0=0+dwvthnm           pvth0=0+dpvthnm           lcit=0+dlcitnm
+ pcit=0+dpcitnm            pvoff=0+dpvoffnm          pu0=0+dpu0nm
+ pvsat=0+dpvsatnm          pa0=0+dpa0nm              ppclm=0+dppclmnm
+ ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-(dxlnm+dlmisnm)                         lmax=2.001e-05
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27338102+(dvthnm+vthmisnm)                   wvth0=2.6223819e-008+dwvthnm
+ k1=0.4215                 k2=0.021428693+dk2m       wk2=-1.5389241e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.002494967       lkvth0we=0
+ wkvth0we=3.5118525e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037243182+dcitnm
+ wcit=-2.760402e-010       voff=-0.087208068+dvoffnm wvoff=-1.7942613e-008
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.03968+du0nm          ua=-9.409475e-010         wua=6.0325826e-016
+ ub=3.3301408e-018         wub=-1.2229961e-024       uc=1.9549414e-010
+ wuc=-3.6989387e-017       vsat=88624.785+dvsatnm    wvsat=-0.00064869448
+ a0=1.8479036+da0nm        wa0=-4.1958111e-007       ags=0.66676281
+ wags=-6.2509304e-008      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.068282182
+ wketa=8.8332865e-009      dwg=0                     dwb=0
+ pclm=0.8839453+dpclmnm    wpclm=-4.8908803e-007     pdiblc1=0
+ pdiblc2=0.00075165316+dpdiblc2nm                    wpdiblc2=2.4378491e-010
+ pdiblcb=0.55              drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.2001967
+ wkt1=-6.0411399e-008      kt1l=0                    kt2=-0.039981652
+ wkt2=1.1179628e-009       ute=-1.7858003            wute=2.5933977e-007
+ ua1=3.6890328e-010        wua1=1.7083852e-015       ub1=-2.0437884e-019
+ wub1=-3.1135541e-024      uc1=-3.0500012e-010       wuc1=2.3580734e-016
+ prt=0                     at=9241.5505              wat=0.2117394
+ jss=2.34e-07              jsd=2.34e-07              jsws=7.68e-13
+ jswd=7.68e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.3                  bvd=11.3                  xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjnm                  cjd=cjnm                  mjs=0.333
+ mjd=0.333                 pbsws=0.29                pbswd=0.29
+ cjsws=cjswnm              cjswd=cjswnm              mjsws=0.146
+ mjswd=0.146               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgnm            cjswgd=cjswgnm            mjswgs=0.713
+ mjswgd=0.713              tpb=0.00149               tcj=0.000913
+ tpbsw=0.001               tcjsw=0.000765            tpbswg=0.00115
+ tcjswg=0.00083            xtis=3                    xtid=3
+ jtsswgs=3.9893e-010       jtsswgd=3.9893e-010       njtsswg=17.974
+ xtsswgs=0.30393           xtsswgd=0.30393           tnjtsswg=0
+ vtsswgs=11.126            vtsswgd=11.126            dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-4e-008               lku0=2e-007               wku0=2e-006
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthnm           pvth0=0+dpvthnm           lk2=0+dlk2m
+ lcit=0+dlcitnm            pcit=0+dpcitnm            lvoff=0+dlvoffnm
+ pvoff=0+dpvoffnm          lu0=0+dlu0nm              pu0=0+dpu0nm
+ lvsat=0+dlvsatnm          pvsat=0+dpvsatnm          la0=0+dla0nm
+ pa0=0+dpa0nm              lpclm=0+dlpclmnm          ppclm=0+dppclmnm
+ lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     6: type=n 
+ lmin=1.2e-006-(dxlnm+dlmisnm)                       lmax=1e-005-(dxlnm+dlmisnm)
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27145188+(dvthnm+vthmisnm)                   lvth0=1.9164926e-008+dlvthnm
+ wvth0=2.7469285e-008+dwvthnm                        pvth0=-1.2372974e-014+dpvthnm
+ k1=0.4215                 k2=0.022010666+dk2m       lk2=-5.7815634e-009+dlk2m
+ wk2=-1.1252518e-009       pk2=-4.109595e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025            lkvth0we=-5.0000074e-011  wkvth0we=3.2300037e-011
+ pkvth0we=2.800004e-017    k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00033954184+dcitnm lcit=-3.2674284e-010+dlcitnm
+ wcit=-3.4720964e-010      pcit=7.0702709e-016+dpcitnm
+ voff=-0.085913801+dvoffnm lvoff=-1.2857789e-008+dlvoffnm
+ wvoff=-1.7994211e-008     pvoff=5.1259464e-016+dpvoffnm
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.039665891+du0nm      lu0=1.4016267e-010+dlu0nm wu0=1.4127134e-010
+ pu0=-1.4034488e-015+dpu0nm                          ua=-9.2452375e-010
+ lua=-1.631605e-016        wua=5.7201666e-016        pua=3.1036722e-022
+ ub=3.3054279e-018         lub=2.4550888e-025        wub=-1.1512217e-024
+ pub=-7.1303682e-031       uc=1.9491912e-010         luc=5.712423e-018
+ wuc=-3.123178e-017        puc=-5.7198492e-023       vsat=86337.115+dvsatnm
+ lvsat=0.022726677+dlvsatnm                          wvsat=0.0020698001
+ pvsat=-2.7006667e-008+dpvsatnm                      a0=1.9060204+da0nm
+ la0=-5.77356e-007+dla0nm  wa0=-4.2064865e-007       pa0=1.0605406e-014+dpa0nm
+ ags=0.65550169            lags=1.1187273e-007       wags=-8.3683991e-008
+ pags=2.1035824e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.067310401
+ lketa=-9.654078e-009      wketa=9.6873198e-009      pketa=-8.4843251e-015
+ dwg=0                     dwb=0                     pclm=0.89796275+dpclmnm
+ lpclm=-1.3925521e-007+dlpclmnm                      wpclm=-6.0917934e-007
+ ppclm=1.1930375e-012+dppclmnm                       pdiblc1=0
+ pdiblc2=0.00047559834+dpdiblc2nm                    lpdiblc2=2.7424445e-009+dlpdiblc2nm
+ wpdiblc2=3.4011808e-010   ppdiblc2=-9.570142e-016+dppdiblc2nm
+ pdiblcb=0.56200267        lpdiblcb=-1.1923958e-007  wpdiblcb=8.8961816e-009
+ ppdiblcb=-8.8378404e-014  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.19449669
+ lkt1=-5.6626361e-008      wkt1=-6.9248864e-008      pkt1=8.7795089e-014
+ kt1l=0                    kt2=-0.039442825          lkt2=-5.352936e-009
+ wkt2=9.8460802e-011       pkt2=1.0128161e-014       ute=-1.7706328
+ lute=-1.5067992e-007      wute=2.3099654e-007       pute=2.8157354e-013
+ ua1=2.8813026e-010        lua1=8.0243305e-016       wua1=1.9044535e-015
+ pua1=-1.9478243e-021      ub1=1.9010069e-020        lub1=-2.2192392e-024
+ wub1=-3.782593e-024       pub1=6.6465141e-030       uc1=-3.4227393e-010
+ luc1=3.7029371e-016       wuc1=2.9736891e-016       puc1=-6.1157844e-022
+ prt=0                     at=8245.2281              lat=0.009897885
+ wat=0.22171558            pat=-9.9107523e-008       jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=5e-007-(dxlnm+dlmisnm)                         lmax=1.2e-006-(dxlnm+dlmisnm)
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29048613+(dvthnm+vthmisnm)                   lvth0=-2.4279126e-009+dlvthnm
+ wvth0=1.9988623e-008+dwvthnm                        pvth0=-3.8867623e-015+dpvthnm
+ k1=0.4215                 k2=0.017481508+dk2m       lk2=-6.4359685e-010+dlk2m
+ wk2=-7.694433e-009        pk2=3.3426156e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0024999999      lkvth0we=-4.9999985e-011  wkvth0we=3.2300122e-011
+ pkvth0we=2.7999944e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00084796581+dcitnm lcit=2.5002348e-010+dlcitnm
+ wcit=6.1866131e-010       pcit=-3.8867623e-016+dpcitnm
+ voff=-0.10084207+dvoffnm  lvoff=4.0771419e-009+dlvoffnm
+ wvoff=-1.6043388e-008     pvoff=-1.7004585e-015+dpvoffnm
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.039280972+du0nm      lu0=5.7682301e-010+dlu0nm wu0=3.99547e-009
+ pu0=-5.7757288e-015+dpu0nm                          ua=-1.1448555e-009
+ lua=8.6788284e-017        wua=1.4687242e-015        pua=-7.0687574e-022
+ ub=3.4685471e-018         lub=6.0463136e-026        wub=-2.2695461e-024
+ pub=5.5561267e-031        uc=1.9072028e-010         luc=1.0475675e-017
+ wuc=-9.9177762e-017       puc=1.9880789e-023        vsat=111054.63+dvsatnm
+ lvsat=-0.0053133667+dlvsatnm                        wvsat=-0.027001159
+ pvsat=5.9720103e-009+dpvsatnm                       a0=1.2635259+da0nm
+ la0=1.5150261e-007+dla0nm wa0=1.8689578e-008        pa0=-4.8778867e-013+dpa0nm
+ ags=0.90734442            lags=-1.738227e-007       wags=-5.6833758e-008
+ pags=1.7989879e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.084881305
+ lketa=1.0278707e-008      wketa=2.2083216e-009      pketa=4.0947392e-030
+ dwg=0                     dwb=0                     pclm=0.66527774+dpclmnm
+ lpclm=1.2470731e-007+dlpclmnm                       wpclm=6.6617263e-007
+ ppclm=-2.5374728e-013+dppclmnm                      pdiblc1=0
+ pdiblc2=0.0022723574+dpdiblc2nm                     lpdiblc2=7.0416503e-010+dlpdiblc2nm
+ wpdiblc2=-1.4312296e-009  ppdiblc2=1.0524381e-015+dppdiblc2nm
+ pdiblcb=0.80249927        lpdiblcb=-3.9206373e-007  wpdiblcb=-1.118377e-007
+ ppdiblcb=4.8584529e-014   drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.23605962
+ lkt1=-9.4765394e-009      wkt1=-5.9042791e-009      pkt1=1.5935725e-014
+ kt1l=0                    kt2=-0.049574625          lkt2=6.1407811e-009
+ wkt2=1.8611338e-008       pkt2=-1.0873217e-014      ute=-1.8771105
+ lute=-2.9889518e-008      wute=5.4721608e-007       pute=-7.7152232e-014
+ ua1=1.0314157e-009        lua1=-4.0764803e-017      wua1=-1.4628165e-016
+ pua1=3.7857065e-022       ub1=-2.12351e-018         lub1=2.1127835e-025
+ wub1=3.9418381e-024       pub1=-2.116235e-030       uc1=-8.052542e-013
+ luc1=-1.7075187e-017      wuc1=-3.596467e-016       puc1=1.3375321e-022
+ prt=0                     at=8509.7956              lat=0.0095977544
+ wat=0.21818406            pat=-9.5101305e-008       jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=2.85e-07             lmax=5e-007-(dxlnm+dlmisnm)
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29124246+(dvthnm+vthmisnm)                   lvth0=-2.7564774e-009+dlvthnm
+ wvth0=6.1884073e-009+dwvthnm                        pvth0=2.1083275e-015+dpvthnm
+ k1=0.4215                 k2=0.0037721656+dk2m      lk2=5.3120158e-009+dlk2m
+ wk2=-3.1286968e-009       pk2=1.3591685e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025170904      lkvth0we=-5.7424431e-011  wkvth0we=2.2729331e-011
+ pkvth0we=3.2157687e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00027627864+dcitnm lcit=1.6711368e-012+dlcitnm
+ wcit=-2.3752197e-010      pcit=-1.6733093e-017+dpcitnm
+ voff=-0.10021197+dvoffnm  lvoff=3.8034113e-009+dlvoffnm
+ wvoff=-5.1861811e-009     pvoff=-6.4170462e-015+dpvoffnm
+ nfactor=1.0323316         lnfactor=-8.057392e-009   wnfactor=-3.2373592e-007
+ pnfactor=8.0678666e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.043125481+du0nm
+ lu0=-1.0933088e-009+dlu0nm                          wu0=-1.8456167e-008
+ pu0=3.9777112e-015+dpu0nm ua=-1.1040138e-009        lua=6.9045835e-017
+ wua=-8.0838774e-016       pua=2.8234722e-022        ub=4.462348e-018
+ lub=-3.7126385e-025       wub=-8.50151e-025         pub=-6.1000943e-032
+ uc=2.2949156e-010         luc=-6.367346e-018        wuc=-6.5948627e-019
+ puc=-2.291752e-023        vsat=117299.26+dvsatnm    lvsat=-0.0080261568+dlvsatnm
+ wvsat=-0.029353755        pvsat=6.9940251e-009+dpvsatnm
+ a0=2.0720855+da0nm        la0=-1.9975186e-007+dla0nm
+ wa0=-2.311799e-006        pa0=5.2462216e-013+dpa0nm ags=0.80332371
+ lags=-1.2863402e-007      wags=1.9029637e-007       pags=7.2540522e-014
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.087519129         lketa=1.1424631e-008
+ wketa=4.717161e-008       pketa=-1.9532952e-014     dwg=0
+ dwb=0                     pclm=0.75849158+dpclmnm   lpclm=8.4213361e-008+dlpclmnm
+ wpclm=2.0204619e-008      ppclm=2.6874148e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=7.7815891e-005+dpdiblc2nm
+ lpdiblc2=1.6575178e-009+dlpdiblc2nm                 wpdiblc2=5.1923291e-009
+ ppdiblc2=-1.8249683e-015+dppdiblc2nm                pdiblcb=0.053169796
+ lpdiblcb=-6.6540022e-008  wpdiblcb=-1.8579499e-007  ppdiblcb=8.0713053e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.28789127           lkt1=1.3040165e-008
+ wkt1=1.264629e-007        pkt1=-4.1567223e-014      kt1l=0
+ kt2=-0.041254031          lkt2=2.5261486e-009       wkt2=-1.0298804e-009
+ pkt2=-2.3406786e-015      ute=-2.3312013            lute=1.673766e-007
+ wute=3.3208722e-007       pute=1.6304048e-014       ua1=8.3610142e-011
+ lua1=3.7098088e-016       wua1=-2.0086289e-015      pua1=1.1876115e-021
+ ub1=-6.9645147e-019       lub1=-4.0866441e-025      wub1=3.0410597e-024
+ pub1=-1.7249189e-030      uc1=-3.8037319e-011       luc1=-9.0083335e-019
+ wuc1=-8.546075e-017       puc1=1.4641347e-023       prt=0
+ at=30583.576              lat=8.4627059e-006        wat=0.0066073804
+ pat=-3.1881623e-009       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-(dxlnm+dlmisnm)                         lmax=2.001e-05
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29426714+(dvthnm+vthmisnm)                   wvth0=8.8895571e-010+dwvthnm
+ k1=0.4215                 k2=0.021742971+dk2m       wk2=-1.9201443e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0024949671      lkvth0we=0
+ wkvth0we=3.5118462e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00052671429+dcitnm
+ wcit=-8.8895571e-011      voff=-0.094671429+dvoffnm wvoff=-8.8895571e-009
+ nfactor=0.82671429        wnfactor=8.8895571e-008   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.041631599+du0nm      wu0=-2.3672891e-009       ua=-4.5759559e-010
+ wua=1.6952385e-017        ub=2.6922127e-018         wub=-4.4918932e-025
+ uc=1.8713229e-010         wuc=-2.6846463e-017       vsat=87745.557+dvsatnm
+ wvsat=0.00041780919       a0=1.7233229+da0nm        wa0=-2.6846463e-007
+ ags=0.65677567            wags=-5.0394899e-008      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.063345143         wketa=2.8446583e-009      dwg=0
+ dwb=0                     pclm=0.17038966+dpclmnm   wpclm=3.7645497e-007
+ pdiblc1=0                 pdiblc2=0.0010820746+dpdiblc2nm
+ wpdiblc2=-1.5701625e-010  pdiblcb=0.58664286        wpdiblcb=-4.4447786e-008
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.26890771           wkt1=2.2935057e-008
+ kt1l=0                    kt2=-0.039060001          ute=-1.5148371
+ wute=-6.9338546e-008      ua1=1.9415333e-009        wua1=-1.9921498e-016
+ ub1=-2.527525e-018        wub1=-2.9557778e-025      uc1=-9.9020857e-011
+ wuc1=-1.40455e-017        prt=0                     at=181235
+ wat=0.003111345           jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthnm           pvth0=0+dpvthnm
+ lk2=0+dlk2m               lcit=0+dlcitnm            pcit=0+dpcitnm
+ lvoff=0+dlvoffnm          pvoff=0+dpvoffnm          lu0=0+dlu0nm
+ pu0=0+dpu0nm              lvsat=0+dlvsatnm          pvsat=0+dpvsatnm
+ la0=0+dla0nm              pa0=0+dpa0nm              lpclm=0+dlpclmnm
+ ppclm=0+dppclmnm          lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm
+ leta0=0+dleta0nm          peta0=0+dpeta0nm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noian_m
+ noib=noibn_m              noic=noicn_m              em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     10: type=n 
+ lmin=1.2e-006-(dxlnm+dlmisnm)                       lmax=1e-005-(dxlnm+dlmisnm)
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29345924+(dvthnm+vthmisnm)                   lvth0=8.0260768e-009+dlvthnm
+ wvth0=7.7435922e-010+dwvthnm                        pvth0=1.1384497e-015+dpvthnm
+ k1=0.4215                 k2=0.022862482+dk2m       lk2=-1.1121687e-008+dlk2m
+ wk2=-2.158505e-009        pk2=2.3679754e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025000001      lkvth0we=-5.0000087e-011  wkvth0we=3.2299973e-011
+ pkvth0we=2.8000056e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00057139128+dcitnm lcit=4.4384004e-010+dlcitnm
+ wcit=-6.5976273e-011      pcit=-2.2768994e-016+dpcitnm
+ voff=-0.092826405+dvoffnm lvoff=-1.832924e-008+dlvoffnm
+ wvoff=-9.6092231e-009     pvoff=7.1494641e-015+dpvoffnm
+ nfactor=0.81726692        lnfactor=9.3854056e-008   wnfactor=1.0035522e-007
+ pnfactor=-1.1384497e-013  eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.041985537+du0nm
+ lu0=-3.5161772e-009+dlu0nm                          wu0=-2.6724595e-009
+ pu0=3.0316915e-015+dpu0nm ua=-4.6166058e-010        lua=4.0383315e-017
+ wua=1.0563631e-017        pua=6.3468571e-023        ub=2.7443089e-018
+ lub=-5.1754584e-025       wub=-4.7058449e-025       pub=2.1254856e-031
+ uc=1.9464444e-010         luc=-7.462894e-017        wuc=-3.0898595e-017
+ puc=4.0255581e-023        vsat=89157.598+dvsatnm    lvsat=-0.01402781+dlvsatnm
+ wvsat=-0.0013514461       pvsat=1.7576525e-008+dpvsatnm
+ a0=1.8036111+da0nm        la0=-7.9761677e-007+dla0nm
+ wa0=-2.9642617e-007       pa0=2.7778173e-013+dpa0nm ags=0.61714733
+ lags=3.9368459e-007       wags=-3.716015e-008       pags=-1.3147956e-013
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.061971611         lketa=-1.3645245e-008
+ wketa=3.2113671e-009      pketa=-3.643039e-015      dwg=0
+ dwb=0                     pclm=0.026945169+dpclmnm  lpclm=1.4250378e-006+dlpclmnm
+ wpclm=4.4736498e-007      ppclm=-7.044499e-013+dppclmnm
+ pdiblc1=0                 pdiblc2=0.00091815608+dpdiblc2nm
+ lpdiblc2=1.628435e-009+dlpdiblc2nm                  wpdiblc2=-1.9670445e-010
+ ppdiblc2=3.9427928e-016+dppdiblc2nm                 pdiblcb=0.61070324
+ lpdiblcb=-2.3902597e-007  wpdiblcb=-5.017761e-008   ppdiblcb=5.6922485e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.27448956           lkt1=5.5452379e-008
+ wkt1=2.7782489e-008       pkt1=-4.8156422e-014      kt1l=0
+ kt2=-0.039437232          lkt2=3.747576e-009        wkt2=9.1677195e-011
+ pkt2=-9.1075976e-016      ute=-1.4868147            lute=-2.783865e-007
+ wute=-1.1327484e-007      pute=4.3648161e-013       ua1=2.3065855e-009
+ lua1=-3.6265816e-015      wua1=-5.4393269e-016      pua1=3.4245705e-021
+ ub1=-3.3272102e-018       lub1=7.9444089e-024       wub1=2.7637218e-025
+ pub1=-5.6819911e-030      uc1=-7.9407113e-011       luc1=-1.9485117e-016
+ wuc1=-2.1488543e-017      puc1=7.3942308e-023       prt=0
+ at=177694.01              lat=0.035177655           wat=0.0161742
+ pat=-1.2977188e-007       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     11: type=n 
+ lmin=5e-007-(dxlnm+dlmisnm)                         lmax=1.2e-006-(dxlnm+dlmisnm)
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.3059539+(dvthnm+vthmisnm)                    lvth0=-6.1481153e-009+dlvthnm
+ wvth0=1.2262255e-009+dwvthnm                        pvth0=6.2584354e-016+dpvthnm
+ k1=0.4215                 k2=0.0098778763+dk2m      lk2=3.608309e-009+dlk2m
+ wk2=1.5287727e-009        pk2=-1.8149463e-015       k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025            lkvth0we=-5.0000022e-011  wkvth0we=3.2300032e-011
+ pkvth0we=2.799999e-017    k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-2.7120629e-005+dcitnm
+ lcit=-1.7359148e-010+dlcitnm                        wcit=-3.770239e-010
+ pcit=1.2516871e-016+dpcitnm                         voff=-0.11439383+dvoffnm
+ lvoff=6.1372834e-009+dlvoffnm                       wvoff=3.9489724e-010
+ pvoff=-4.1994101e-015+dpvoffnm                      nfactor=0.85451889
+ lnfactor=5.1594686e-008   wnfactor=5.5168592e-008   pnfactor=-6.2584354e-014
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.042439313+du0nm      lu0=-4.030949e-009+dlu0nm
+ wu0=1.644024e-010         pu0=-1.8650137e-016+dpu0nm
+ ua=2.1769743e-011         lua=-5.0802971e-016       wua=5.3607733e-017
+ pua=1.463848e-023         ub=1.6822931e-018         lub=6.8722613e-025
+ wub=-1.0282e-025          pub=-2.0465084e-031       uc=7.1647684e-011
+ luc=6.4901046e-017        wuc=4.5257297e-017        puc=-4.6137186e-023
+ vsat=70093.492+dvsatnm    lvsat=0.0075988935+dlvsatnm
+ wvsat=0.022684701         pvsat=-9.6905613e-009+dpvsatnm
+ a0=1.3469087+da0nm        la0=-2.7952452e-007+dla0nm
+ wa0=-8.2453843e-008       pa0=3.5047238e-014+dpa0nm ags=0.90295225
+ lags=6.9461774e-008       wags=-5.1506051e-008      pags=-1.1520528e-013
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.081514402         lketa=8.524488e-009
+ wketa=-1.8757321e-009     pketa=2.127868e-015       dwg=0
+ dwb=0                     pclm=1.4050176+dpclmnm    lpclm=-1.3827515e-007+dlpclmnm
+ wpclm=-2.3113182e-007     ppclm=6.5250447e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0014254861+dpdiblc2nm
+ lpdiblc2=1.0529096e-009+dlpdiblc2nm                 wpdiblc2=-4.0397474e-010
+ ppdiblc2=6.2941085e-016+dppdiblc2nm                 pdiblcb=0.71030001
+ lpdiblcb=-3.5201053e-007  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.22260406
+ lkt1=-3.4075676e-009      wkt1=-2.2225872e-008      pkt1=8.5740627e-015
+ kt1l=0                    kt2=-0.029856533          lkt2=-7.120961e-009
+ wkt2=-5.3067083e-009      pkt2=5.2132767e-015       ute=-1.6312426
+ lute=-1.1454463e-007      wute=2.4897829e-007       pute=2.5534416e-014
+ ua1=-1.578534e-009        lua1=7.8077564e-016       wua1=3.0195874e-015
+ pua1=-6.1795791e-022      ub1=6.4433307e-018        lub1=-3.1394881e-024
+ wub1=-6.4497397e-024      pub1=1.9482447e-030       uc1=-3.6118503e-010
+ luc1=1.2480333e-016       wuc1=7.7493971e-017       puc1=-3.8345435e-023
+ prt=0                     at=319606.71              lat=-0.12581095
+ wat=-0.1591765            pat=6.9149456e-008        jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     12: type=n 
+ lmin=2.85e-07             lmax=5e-007-(dxlnm+dlmisnm)
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.28895738+(dvthnm+vthmisnm)                   lvth0=1.2355124e-009+dlvthnm
+ wvth0=8.9602149e-009+dwvthnm                        pvth0=-2.7339561e-015+dpvthnm
+ k1=0.4215                 k2=0.0053696129+dk2m      lk2=5.5667888e-009+dlk2m
+ wk2=-5.0664004e-009       pk2=1.0501288e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025170904      lkvth0we=-5.7424447e-011  wkvth0we=2.2729301e-011
+ pkvth0we=3.2157706e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00018104609+dcitnm lcit=-1.0672318e-010+dlcitnm
+ wcit=-3.5303905e-010      pcit=1.1474921e-016+dpcitnm
+ voff=-0.083666986+dvoffnm lvoff=-7.2110739e-009+dlvoffnm
+ wvoff=-2.5255244e-008     pvoff=6.9435243e-015+dpvoffnm
+ nfactor=0.93742565        lnfactor=1.5578329e-008   wnfactor=-2.0861505e-007
+ pnfactor=5.2008536e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.030598998+du0nm
+ lu0=1.1127206e-009+dlu0nm wu0=-3.2615426e-009       pu0=1.3017977e-015+dpu0nm
+ ua=-1.9857284e-009        lua=3.6406763e-016        wua=2.6113202e-016
+ pua=-7.5514222e-023       ub=5.1749416e-018         lub=-8.3005022e-025
+ wub=-1.714527e-024        pub=4.9550692e-031        uc=3.6586384e-010
+ luc=-6.2912335e-017       wuc=-1.6607905e-016       puc=4.5671552e-023
+ vsat=100651.61+dvsatnm    lvsat=-0.0056761629+dlvsatnm
+ wvsat=-0.0091601583       pvsat=4.1434825e-009+dpvsatnm
+ a0=0.44652432+da0nm       la0=1.1162048e-007+dla0nm wa0=-3.3999326e-007
+ pa0=1.4692751e-013+dpa0nm ags=1.480447              lags=-1.8141349e-007
+ wags=-6.3105417e-007      pags=1.3656201e-013       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.049741217         lketa=-5.2784192e-009     wketa=1.3470019e-009
+ pketa=7.2784792e-016      dwg=0                     dwb=0
+ pclm=0.93364125+dpclmnm   lpclm=6.6500174e-008+dlpclmnm
+ wpclm=-1.9225193e-007     ppclm=4.8360244e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0033513003+dpdiblc2nm
+ lpdiblc2=2.1629745e-010+dlpdiblc2nm                 wpdiblc2=1.2215924e-009
+ ppdiblc2=-7.676804e-017+dppdiblc2nm                 pdiblcb=-0.19865316
+ lpdiblcb=4.2856902e-008   wpdiblcb=1.1966626e-007   ppdiblcb=-5.1985415e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
