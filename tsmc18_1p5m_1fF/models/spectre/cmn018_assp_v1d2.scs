+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     16: type=p 
+ lmin=2.5e-07              lmax=5e-007-dxlpm         wmin=2.2e-07
+ wmax=5.3e-007-dxwpm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.18140812+dvthpm   lvth0=6.2970702e-009+dlvthpm
+ wvth0=7.4171519e-009+dwvthpm                        pvth0=-2.7076254e-015+dpvthpm
+ k1=0.1926                 k2=0.056367717+dk2pm      lk2=1.7803066e-009+dlk2pm
+ wk2=-4.9795715e-010+dwk2pm                          pk2=-8.8126087e-016+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022650892     lkvth0we=6.5068925e-011
+ wkvth0we=-3.067071e-011   pkvth0we=-3.9020657e-018  k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0023958264+dcitpm
+ lcit=6.2187081e-010+dlcitpm                         wcit=6.0345414e-010+dwcitpm
+ pcit=-1.6157878e-016+dpcitpm                        voff=-0.11914358+dvoffpm
+ lvoff=1.8685885e-010+dlvoffpm                       wvoff=3.8467817e-009+dwvoffpm
+ pvoff=-1.0794119e-015+dpvoffpm                      nfactor=1
+ eta0=0.13511485+deta0pm   leta0=3.5081744e-008+dleta0pm
+ weta0=4.2132546e-008+dweta0pm                       peta0=-1.9738002e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.017654768            lu0=-4.6602309e-010       wu0=-3.8847604e-010
+ pu0=1.8199092e-016        ua=3.5975652e-009+duapm   lua=-3.9108333e-016+dluapm
+ wua=-4.1337021e-016+dwuapm                          pua=1.0711024e-022+dpuapm
+ ub=-6.7942838e-019        lub=6.1256173e-025        wub=3.3585369e-025
+ pub=-1.086732e-031        uc=-1.5964568e-010        luc=5.9124775e-017
+ wuc=3.4262662e-017        puc=-1.9206441e-023       vsat=144081.64
+ lvsat=0.0041311722+dlvsatpm                         wvsat=0.010482761+dwvsatpm
+ pvsat=-4.910901e-009+dpvsatpm                       a0=0.40280244
+ la0=1.1909401e-007        wa0=1.9218771e-007        pa0=-2.099438e-014
+ ags=0.33665966+dagspm     lags=1.4913417e-007       wags=2.7737587e-007
+ pags=-9.083049e-014       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.053436542
+ lketa=-3.54147e-009       wketa=-5.4672574e-010     pketa=1.548114e-015
+ dwg=0                     dwb=0                     pclm=-0.14143722
+ lpclm=1.879165e-007+dlpclmpm                        wpclm=5.6982411e-007+dwpclmpm
+ ppclm=-1.1696825e-013+dppclmpm                      pdiblc1=0
+ pdiblc2=0.020213556+dpdiblc2pm                      lpdiblc2=-3.703126e-009+dlpdiblc2pm
+ wpdiblc2=-3.4056526e-009+dwpdiblc2pm                ppdiblc2=6.4110509e-016+dppdiblc2pm
+ pdiblcb=0.28376547        lpdiblcb=-9.3494251e-008  wpdiblcb=-2.5391025e-007
+ ppdiblcb=5.838845e-014    drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.306                 rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.31123593
+ lkt1=-1.2612922e-008      wkt1=-2.9908938e-008      pkt1=5.6742046e-015
+ kt1l=0                    kt2=0.0022795324          lkt2=-1.3502592e-008
+ wkt2=-1.6443239e-008      pkt2=5.8782982e-015       ute=-1.7002527
+ lute=3.1369373e-007       wute=4.6860511e-008       pute=-7.0402452e-014
+ ua1=-1.1665569e-009       lua1=2.8379679e-015       wua1=1.2596353e-015
+ pua1=-8.723248e-022       ub1=-5.2240365e-018       lub1=-2.7204144e-024
+ wub1=-1.3761119e-024      pub1=9.6585254e-031       uc1=-2.296169e-010
+ luc1=3.352588e-017        wuc1=4.2811689e-017       puc1=-1.7896124e-023
+ prt=0                     at=319506.63              lat=-0.061979192
+ wat=0.021132548           pat=-5.6607162e-009       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lnfactor=0+dlnfactorpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     } 
endsection mos_m
 
// **************************************************************

section mos_3m
// *********************************************************************************************
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V MED-Vt NMOS DEVICE MODELS          
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        mismatch   model         * 
// *********************************
 
inline subckt mench3_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-7 dmci=3.15e-007 xw= + 0 + 
+ dxwn_3m ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg 
+ + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + 
+ (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) 
+ * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_3m 
+ temp1=parn1_3m temp2=parn2_3m fac1=0.579082 * temp1 * sigma + 0.815269 * temp2 
+ * sigma fac2=0.579082 * temp1 * sigma - 0.815269 * temp2 * sigma lef=l * factor 
+ - 0.015e-6 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisn_3m=0.00376962 * geo_fac * fac1 * mismatchflag dlmisn_3m=0.00153195 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisn_3m= - 0.00153195 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisn_3m=0.00153195 * geo_fac * toxn_3m * fac2 * mismatchflag 
mench3_mac ( n1 n2 n3 n4 ) mench3 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model mench3 bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln_3m+dlmisn_3m)                     lmax=900.01e-6
+ wmin=1.003e-005-(dxwn_3m+dwmisn_3m)                 wmax=900.04e-6
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.4928+(dvthn_3m+vthmisn_3m)
+ k1=0.75128                k2=0.0011+dk2n_3m         k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00025
+ voff=-0.126               nfactor=0.913             eta0=0.028
+ etab=-0.044               u0=0.046+du0n_3m          ua=-3.0802e-010
+ ub=2.77e-018              uc=1.4085e-010            vsat=70000+dvsatn_3m
+ a0=1.1698                 ags=0.3356                a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.045646            dwg=0                     dwb=0
+ pclm=0.178                pdiblc1=0                 pdiblc2=0.0002
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.28364              kt1l=0                    kt2=-0.045
+ ute=-1.2203               ua1=2.4158e-009           ub1=-2.0096e-018
+ uc1=-6.194e-011           prt=0                     at=150000
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     lvth0=0+dlvthn_3m
+ wvth0=0+dwvthn_3m         pvth0=0+dpvthn_3m         pvsat=0+dpvsatn_3m
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-5.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=3.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-9.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=4.60e-03             lk2we=8.50e-10            wk2we=-1.50e-10
+ lcit=0+dlcitn_3m          pcit=0+dpcitn_3m          fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     2: type=n 
+ lmin=1.2e-006-(dxln_3m+dlmisn_3m)                   lmax=1e-005-(dxln_3m+dlmisn_3m)
+ wmin=1.003e-005-(dxwn_3m+dwmisn_3m)                 wmax=900.04e-6
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.49082321+(dvthn_3m+vthmisn_3m)
+ lvth0=1.9658154e-008+dlvthn_3m                      k1=0.75128
+ k2=0.0020975009+dk2n_3m   lk2=-9.9196081e-009       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00025
+ voff=-0.12593497          lvoff=-6.4664981e-010     nfactor=0.92119329
+ lnfactor=-8.1477876e-008  eta0=0.028                etab=-0.044
+ u0=0.046+du0n_3m          ua=-2.6984836e-010        lua=-3.7959637e-016
+ ub=2.797441e-018          lub=-2.7288622e-025       uc=1.4363182e-010
+ luc=-2.7663679e-017       vsat=70000+dvsatn_3m      a0=1.2654443
+ la0=-9.5113134e-007       ags=0.32852516            lags=7.03555e-008
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.04226165          lketa=-3.3655536e-008
+ dwg=0                     dwb=0                     pclm=0.17292796
+ lpclm=5.0438685e-008      pdiblc1=0                 pdiblc2=0.00018400357
+ lpdiblc2=1.5907585e-010   pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.28146162           lkt1=-2.1662769e-008
+ kt1l=0                    kt2=-0.045                ute=-1.2280121
+ lute=7.6692668e-008       ua1=2.3398625e-009        lua1=7.5515765e-016
+ ub1=-1.9531963e-018       lub1=-5.6090405e-025      uc1=-7.1088072e-011
+ luc1=9.0972636e-017       prt=0                     at=168207.32
+ lat=-0.18106195           tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ wvth0=0+dwvthn_3m         pvth0=0+dpvthn_3m         pvsat=0+dpvsatn_3m
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-5.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=3.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-9.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=4.60e-03             lk2we=8.50e-10            wk2we=-1.50e-10
+ lcit=0+dlcitn_3m          pcit=0+dpcitn_3m          fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-(dxln_3m+dlmisn_3m)
+ wmin=1.003e-005-(dxwn_3m+dwmisn_3m)                 wmax=900.04e-6
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50718331+(dvthn_3m+vthmisn_3m)
+ lvth0=9.3466904e-010+dlvthn_3m                      k1=0.75128
+ k2=-0.005726087+dk2n_3m   lk2=-9.6582467e-010       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00020462833
+ lcit=5.1926058e-011+dlcitn_3m                       voff=-0.13421318
+ lvoff=8.8274298e-009      nfactor=0.713885          lnfactor=1.5577817e-007
+ eta0=0.028                etab=-0.044               u0=0.0405554+du0n_3m
+ lu0=6.2311269e-009        ua=-2.4221362e-010        lua=-4.1122322e-016
+ ub=2.201925e-018          lub=4.0865807e-025        uc=1.0305361e-010
+ luc=1.8776462e-017        vsat=70000+dvsatn_3m      a0=0.37974251
+ la0=6.2518973e-008        ags=0.6431739             lags=-2.897474e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.06353386          lketa=-9.3103421e-009
+ dwg=0                     dwb=0                     pclm=0.1734432
+ lpclm=4.9849015e-008      pdiblc1=0                 pdiblc2=0.00034387097
+ lpdiblc2=-2.3885987e-011  pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.31417391           lkt1=1.5775136e-008
+ kt1l=0                    kt2=-0.0422777            lkt2=-3.1155635e-009
+ ute=-1.4629484            lute=3.4556791e-007       ua1=3.7501474e-009
+ lua1=-8.5885699e-016      ub1=-4.7363432e-018       lub1=2.6242962e-024
+ uc1=-1.5249414e-010       luc1=1.8413863e-016       prt=0
+ at=14537.167              lat=-0.0051926058         tnoimod=0
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3m                cjd=cjn_3m                mjs=0.325
+ mjd=0.325                 pbsws=0.630               pbswd=0.630
+ cjsws=cjswn_3m            cjswd=cjswn_3m            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3m          cjswgd=cjswgn_3m          mjswgs=0.410
+ mjswgd=0.410              tpb=0.0017                tcj=0.00092
+ tpbsw=0.00175             tcjsw=0.000769            tpbswg=0.00146
+ tcjswg=0.0011             xtis=3                    xtid=3
+ jtsswgs=1e-010            jtsswgd=1e-010            njtsswg=45
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     wvth0=0+dwvthn_3m         pvth0=0+dpvthn_3m
+ pvsat=0+dpvsatn_3m        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           pcit=0+dpcitn_3m          fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     4: type=n 
+ lmin=1e-005-(dxln_3m+dlmisn_3m)                     lmax=900.01e-6
+ wmin=1.23e-006-(dxwn_3m+dwmisn_3m)                  wmax=1.003e-005-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.49089139+(dvthn_3m+vthmisn_3m)
+ wvth0=1.9053263e-008+dwvthn_3m                      k1=0.75128
+ k2=0.00076397727+dk2n_3m  wk2=3.3544477e-009        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00024462364
+ wcit=5.3671163e-011       voff=-0.12634946          wvoff=3.4886256e-009
+ nfactor=0.90130641        wnfactor=1.1673478e-007   eta0=0.028336023
+ weta0=-3.3544477e-009     etab=-0.044               u0=0.046134409+du0n_3m
+ wu0=-1.3417791e-009       ua=-3.4013625e-010        wua=3.2061006e-016
+ ub=2.8545433e-018         wub=-8.4397904e-025       uc=1.43932e-010
+ wuc=-3.0766994e-017       vsat=70000+dvsatn_3m      a0=1.1815339
+ wa0=-1.1713731e-007       ags=0.33897367            wags=-3.3678655e-008
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.045646            dwg=0
+ dwb=0                     pclm=0.18579573           wpclm=-7.7823186e-008
+ pdiblc1=0                 pdiblc2=0.00020403227     wpdiblc2=-4.0253372e-011
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.28402172           wkt1=3.8106526e-009       kt1l=0
+ kt2=-0.042715046          wkt2=-2.2810244e-008      ute=-1.2157839
+ wute=-4.5083777e-008      ua1=2.2686221e-009        wua1=1.4692481e-015
+ ub1=-1.6409159e-018       wub1=-3.6805e-024         uc1=-5.3632174e-011
+ wuc1=-8.2935365e-017      prt=0                     at=150106.18
+ wat=-0.0010600055         tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3m         pvth0=0+dpvthn_3m         saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           pvsat=0+dpvsatn_3m
+ lcit=0+dlcitn_3m          pcit=0+dpcitn_3m          fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1.2e-006-(dxln_3m+dlmisn_3m)                   lmax=1e-005-(dxln_3m+dlmisn_3m)
+ wmin=1.23e-006-(dxwn_3m+dwmisn_3m)                  wmax=1.003e-005-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.48877476+(dvthn_3m+vthmisn_3m)
+ lvth0=2.1048804e-008+dlvthn_3m                      wvth0=2.0449274e-008+dwvthn_3m
+ pvth0=-1.3882579e-014+dpvthn_3m                     k1=0.75128
+ k2=0.0017920686+dk2n_3m   lk2=-1.0223813e-008       wk2=3.0490702e-009
+ pk2=3.0368142e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=2                    dvt1=0.182
+ dvt2=0.0001               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2                  minv=-0.3
+ voffl=-2.6873e-010        dvtp0=3.6e-007            dvtp1=0.001
+ lpe0=1.8e-008             lpeb=1e-010               xj=1.4e-007
+ ngate=1.0051e+020         ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00024715827         lcit=-2.5205528e-011+dlcitn_3m
+ wcit=2.8368457e-011       pcit=2.5162174e-016+dpcitn_3m
+ voff=-0.12637359          lvoff=2.3988944e-010      wvoff=4.3785828e-009
+ pvoff=-8.8501441e-015     nfactor=0.91060096        lnfactor=-9.2429244e-008
+ wnfactor=1.0574119e-007   pnfactor=1.0932531e-013   eta0=0.028336023
+ weta0=-3.3544477e-009     etab=-0.044               u0=0.046134409+du0n_3m
+ wu0=-1.3417791e-009       ua=-3.0159007e-010        lua=-3.8332088e-016
+ wua=3.1687119e-016        pua=3.7181017e-023        ub=2.8825962e-018
+ lub=-2.7897031e-025       wub=-8.5008659e-025       pub=6.0736283e-032
+ uc=1.4686502e-010         luc=-2.9167319e-017       wuc=-3.2276431e-017
+ puc=1.5010539e-023        vsat=70000+dvsatn_3m      a0=1.2764074
+ la0=-9.4346539e-007       wa0=-1.094418e-007        pa0=-7.6527717e-014
+ ags=0.33551898            lags=3.4355053e-008       wags=-6.9817898e-008
+ pags=3.5938526e-013       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.042430037
+ lketa=-3.198102e-008      wketa=1.6809722e-009      pketa=-1.671636e-014
+ dwg=0                     dwb=0                     pclm=0.18144038
+ lpclm=4.3311605e-008      wpclm=-8.4977744e-008     ppclm=7.1148217e-014
+ pdiblc1=0                 pdiblc2=0.00019165425     lpdiblc2=1.2309279e-010
+ wpdiblc2=-7.6375166e-011  ppdiblc2=3.5921173e-016   pdiblcb=0
+ drout=0.56                pvag=0.36                 delta=0.01
+ pscbe1=5e+008             pscbe2=1e-010             fprout=100
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=280                   rdw=280
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.1917e+009         cgidl=20                  egidl=0.9035
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3m              cgdo=cgon_3m              cgbo=0
+ cgdl=cgln_3m              cgsl=cgln_3m              clc=1e-007
+ cle=0.6                   cf=cfn_3m                 ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=5.5934
+ noff=1.631                voffcv=-0.052318          kt1=-0.28285947
+ lkt1=-1.155796e-008       wkt1=1.395442e-008        pkt1=-1.0087429e-013
+ kt1l=0                    kt2=-0.04257835           lkt2=-1.3593602e-009
+ wkt2=-2.4174845e-008      pkt2=1.3570221e-014       ute=-1.2249381
+ lute=9.1033744e-008       wute=-3.068741e-008       pute=-1.431641e-013
+ ua1=2.1937858e-009        lua1=7.4420628e-016       wua1=1.4582545e-015
+ pua1=1.0932531e-022       ub1=-1.5908156e-018       lub1=-4.9822051e-025
+ wub1=-3.6175748e-024      pub1=-6.2575725e-031      uc1=-6.311834e-011
+ luc1=9.4334792e-017       wuc1=-7.9560245e-017      puc1=-3.3563738e-023
+ prt=0                     at=168640.4               lat=-0.18431277
+ wat=-0.0043233565         pat=3.2452264e-008        tnoimod=0
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3m                cjd=cjn_3m                mjs=0.325
+ mjd=0.325                 pbsws=0.630               pbswd=0.630
+ cjsws=cjswn_3m            cjswd=cjswn_3m            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3m          cjswgd=cjswgn_3m          mjswgs=0.410
+ mjswgd=0.410              tpb=0.0017                tcj=0.00092
+ tpbsw=0.00175             tcjsw=0.000769            tpbswg=0.00146
+ tcjswg=0.0011             xtis=3                    xtid=3
+ jtsswgs=1e-010            jtsswgd=1e-010            njtsswg=45
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           xgw=0
+ xgl=0                     pvsat=0+dpvsatn_3m        fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     6: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-(dxln_3m+dlmisn_3m)
+ wmin=1.23e-006-(dxwn_3m+dwmisn_3m)                  wmax=1.003e-005-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50654512+(dvthn_3m+vthmisn_3m)
+ lvth0=7.1133034e-010+dlvthn_3m                      wvth0=6.3709102e-009+dwvthn_3m
+ pvth0=2.2295455e-015+dpvthn_3m                      k1=0.75128
+ k2=-0.00616926+dk2n_3m    lk2=-1.1123907e-009       wk2=4.4241073e-009
+ pk2=1.4631393e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=2                    dvt1=0.182
+ dvt2=0.0001               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2                  minv=-0.3
+ voffl=-2.6873e-010        dvtp0=3.6e-007            dvtp1=0.001
+ lpe0=1.8e-008             lpeb=1e-010               xj=1.4e-007
+ ngate=1.0051e+020         ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0002009191          lcit=2.7713351e-011+dlcitn_3m
+ wcit=3.7028559e-011       pcit=2.417106e-016+dpcitn_3m
+ voff=-0.13418208          lvoff=9.1763965e-009      wvoff=-3.1051004e-010
+ pvoff=-3.4836649e-015     nfactor=0.67542854        lnfactor=1.7671618e-007
+ wnfactor=3.8390312e-007   pnfactor=-2.0901989e-013  eta0=0.028336023
+ weta0=-3.3544477e-009     etab=-0.044               u0=0.04020194+du0n_3m
+ lu0=6.7894737e-009        wu0=3.5285212e-009        pu0=-5.5738638e-015
+ ua=-2.9021509e-010        lua=-3.9633909e-016       wua=4.7918905e-016
+ pua=-1.4858527e-022       ub=2.2599318e-018         lub=4.3364409e-025
+ wub=-5.7907083e-025       pub=-2.4943041e-031       uc=1.0376549e-010
+ luc=2.0158371e-017        wuc=-7.1066121e-018       puc=-1.3795313e-023
+ vsat=70000+dvsatn_3m      a0=0.37940394             la0=8.3119176e-008
+ wa0=3.3799567e-009        pa0=-2.0564771e-013       ags=0.66835213
+ lags=-3.4655918e-007      wags=-2.5134926e-007      pags=5.6714064e-013
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.061145661         lketa=-1.0561737e-008
+ wketa=-2.3840918e-008     pketa=1.2492422e-014      dwg=0
+ dwb=0                     pclm=0.18207045           lpclm=4.2590508e-008
+ wpclm=-8.6124147e-008     ppclm=7.2460229e-014      pdiblc1=0
+ pdiblc2=0.00029849235     lpdiblc2=8.2085656e-013   wpdiblc2=4.5300568e-010
+ ppdiblc2=-2.4664347e-016  pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.30982333           lkt1=1.9301096e-008
+ wkt1=-4.3431019e-008      pkt1=-3.519895e-014       kt1l=0
+ kt2=-0.040412034          lkt2=-3.8386225e-009      wkt2=-1.8624571e-008
+ pkt2=7.2181536e-015       ute=-1.4832568            lute=3.8666921e-007
+ wute=2.0273443e-007       pute=-4.1030605e-013      ua1=3.6135895e-009
+ lua1=-8.8070231e-016      wua1=1.3632297e-015       pua1=2.1807742e-022
+ ub1=-4.4210649e-018       lub1=2.7408867e-024       wub1=-3.1473599e-024
+ pub1=-1.1638994e-030      uc1=-1.6348691e-010       luc1=2.092026e-016
+ wuc1=1.0973857e-016       puc1=-2.5020866e-022      prt=0
+ at=9945.2093              lat=-0.0026924687         wat=0.045840592
+ pat=-2.4958369e-008       tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           xgl=0
+ pvsat=0+dpvsatn_3m        fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     7: type=n 
+ lmin=1e-005-(dxln_3m+dlmisn_3m)                     lmax=900.01e-6
+ wmin=5.3e-007-(dxwn_3m+dwmisn_3m)                   wmax=1.23e-006-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50568954+(dvthn_3m+vthmisn_3m)
+ wvth0=1.5500087e-009+dwvthn_3m                      k1=0.75128
+ k2=0.0074624+dk2n_3m      wk2=-4.5684467e-009       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00029
+ voff=-0.12229646          wvoff=-1.3052705e-009     nfactor=1.0689714
+ wnfactor=-8.1579406e-008  eta0=0.033776571          weta0=-9.7895287e-009
+ etab=-0.044               u0=0.044310286+du0n_3m    wu0=8.1579406e-010
+ ua=1.9092936e-011         wua=-1.0428622e-016       ub=2.0520269e-018
+ wub=1.0523743e-025        uc=1.2156859e-010         wuc=-4.3155506e-018
+ vsat=70000+dvsatn_3m      a0=0.97800829             wa0=1.235928e-007
+ ags=0.30739629            wags=3.6710733e-009       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.042182945         wketa=-4.096102e-009      dwg=0
+ dwb=0                     pclm=0.12                 pdiblc1=0
+ pdiblc2=0.00013551429     wpdiblc2=4.0789703e-011   pdiblcb=0
+ drout=0.56                pvag=0.36                 delta=0.01
+ pscbe1=5e+008             pscbe2=1e-010             fprout=100
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=280                   rdw=280
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.1917e+009         cgidl=20                  egidl=0.9035
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3m              cgdo=cgon_3m              cgbo=0
+ cgdl=cgln_3m              cgsl=cgln_3m              clc=1e-007
+ cle=0.6                   cf=cfn_3m                 ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=5.5934
+ noff=1.631                voffcv=-0.052318          kt1=-0.29487017
+ wkt1=1.6642199e-008       kt1l=0                    kt2=-0.067517714
+ wkt2=6.5263525e-009       ute=-1.1224405            wute=-1.5549035e-007
+ ua1=4.4872975e-009        wua1=-1.1550012e-015      ub1=-5.5979828e-018
+ wub1=9.9991878e-025       uc1=-1.2194985e-010       wuc1=-2.1292225e-018
+ prt=0                     at=151492.95              wat=-0.0027002783
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     lvth0=0+dlvthn_3m
+ pvth0=0+dpvthn_3m         saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           pvsat=0+dpvsatn_3m        lcit=0+dlcitn_3m
+ pcit=0+dpcitn_3m          fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     8: type=n 
+ lmin=1.2e-006-(dxln_3m+dlmisn_3m)                   lmax=1e-005-(dxln_3m+dlmisn_3m)
+ wmin=5.3e-007-(dxwn_3m+dwmisn_3m)                   wmax=1.23e-006-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.5044751+(dvthn_3m+vthmisn_3m)
+ lvth0=1.207698e-008+dlvthn_3m                       wvth0=1.8789059e-009+dwvthn_3m
+ pvth0=-3.2707051e-015+dpvthn_3m                     k1=0.75128
+ k2=0.0081802841+dk2n_3m   lk2=-7.1389696e-009       wk2=-4.5069111e-009
+ pk2=-6.1193837e-016       k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=2                    dvt1=0.182
+ dvt2=0.0001               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2                  minv=-0.3
+ voffl=-2.6873e-010        dvtp0=3.6e-007            dvtp1=0.001
+ lpe0=1.8e-008             lpeb=1e-010               xj=1.4e-007
+ ngate=1.0051e+020         ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00025813608         lcit=3.1686949e-010+dlcitn_3m
+ wcit=1.5383901e-011       pcit=-1.5298459e-016+dpcitn_3m
+ voff=-0.12178344          lvoff=-5.1016606e-009     wvoff=-1.0506404e-009
+ pvoff=-2.5321588e-015     nfactor=1.0779413         lnfactor=-8.9200723e-008
+ wnfactor=-9.2188993e-008  pnfactor=1.0550662e-013   eta0=0.033776571
+ weta0=-9.7895287e-009     etab=-0.044               u0=0.044220587+du0n_3m
+ lu0=8.9200723e-010        wu0=9.2188993e-010        pu0=-1.0550662e-015
+ ua=5.1495949e-011         lua=-3.2223046e-016       wua=-1.0075895e-016
+ pua=-3.5076729e-023       ub=2.0615509e-018         lub=-9.4711657e-026
+ wub=1.2104572e-025        pub=-1.5720486e-031       uc=1.2128554e-010
+ luc=2.8148031e-018        wuc=-2.0210152e-018       puc=-2.2817916e-023
+ vsat=70000+dvsatn_3m      a0=1.0688465              la0=-9.0333717e-007
+ wa0=1.3606119e-007        pa0=-1.2399137e-013       ags=0.28204356
+ lags=2.5211915e-007       wags=-6.5671783e-009      pags=1.0181388e-013
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.037656489         lketa=-4.5013155e-008
+ wketa=-3.9651797e-009     pketa=-1.3019516e-015     dwg=0
+ dwb=0                     pclm=0.11587474           lpclm=4.1023464e-008
+ wpclm=-7.426711e-009      ppclm=7.385463e-014       pdiblc1=0
+ pdiblc2=8.5421123e-005    lpdiblc2=4.9814945e-010   wpdiblc2=4.9277373e-011
+ ppdiblc2=-8.4405292e-017  pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.28164975           lkt1=-1.3147e-007
+ wkt1=1.2523557e-008       pkt1=4.0957668e-014       kt1l=0
+ kt2=-0.069325867          lkt2=1.7981107e-008       wkt2=7.462118e-009
+ pkt2=-9.3056834e-015      ute=-1.1197641            lute=-2.6614924e-008
+ wute=-1.5508718e-007      pute=-4.0092514e-015      ua1=4.3802217e-009
+ lua1=1.064811e-015        wua1=-1.1278619e-015      pua1=-2.6988592e-022
+ ub1=-5.4442536e-018       lub1=-1.5287544e-024      wub1=9.4027168e-025
+ pub1=5.9315819e-031       uc1=-1.3009753e-010       luc1=8.1024283e-017
+ wuc1=-3.3726322e-019      puc1=-1.7820067e-023      prt=0
+ at=167919.47              lat=-0.16335282           wat=-0.0034706405
+ pat=7.6608353e-009        tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           xgl=0
+ pvsat=0+dpvsatn_3m        fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     9: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-(dxln_3m+dlmisn_3m)
+ wmin=5.3e-007-(dxwn_3m+dwmisn_3m)                   wmax=1.23e-006-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.51482444+(dvthn_3m+vthmisn_3m)
+ lvth0=2.3256939e-010+dlvthn_3m                      wvth0=-3.4218727e-009+dwvthn_3m
+ pvth0=2.795824e-015+dpvthn_3m                       k1=0.75128
+ k2=0.0028224165+dk2n_3m   lk2=-1.0071044e-009       wk2=-6.2112477e-009
+ pk2=1.3386066e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=2                    dvt1=0.182
+ dvt2=0.0001               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2                  minv=-0.3
+ voffl=-2.6873e-010        dvtp0=3.6e-007            dvtp1=0.001
+ lpe0=1.8e-008             lpeb=1e-010               xj=1.4e-007
+ ngate=1.0051e+020         ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00051157023         lcit=2.6824242e-011+dlcitn_3m
+ wcit=-3.304096e-010       pcit=2.4276224e-016+dpcitn_3m
+ voff=-0.13544096          lvoff=1.0528824e-008      wvoff=1.1784961e-009
+ pvoff=-5.0833163e-015     nfactor=0.93741303        lnfactor=7.1628288e-008
+ wnfactor=7.4027872e-008   pnfactor=-8.4721939e-014  eta0=0.033776571
+ weta0=-9.7895287e-009     etab=-0.044               u0=0.043811003+du0n_3m
+ lu0=1.3607594e-009        wu0=-7.4027872e-010       pu0=8.4721939e-016
+ ua=2.7788725e-010         lua=-5.8132626e-016       wua=-1.9276241e-016
+ pua=7.0217543e-023        ub=1.7869663e-018         lub=2.1953951e-025
+ wub=-1.9647135e-026       pub=3.8124872e-033        uc=1.1388698e-010
+ luc=1.128216e-017         wuc=-1.9078304e-017       puc=-3.2965306e-024
+ vsat=70000+dvsatn_3m      a0=0.30349189             la0=-2.7419409e-008
+ wa0=9.3168724e-008        pa0=-7.4902666e-014       ags=1.4370227
+ lags=-1.0697082e-006      wags=-1.1605328e-006      pags=1.4224814e-012
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.1020558           lketa=2.8689278e-008
+ wketa=2.4547592e-008      pketa=-3.3933678e-014     dwg=0
+ dwb=0                     pclm=0.067235364          lpclm=9.6689287e-008
+ wpclm=4.9702797e-008      ppclm=8.4721939e-015      pdiblc1=0
+ pdiblc2=0.00072095419     lpdiblc2=-2.2919272e-010  wpdiblc2=-4.6682183e-011
+ ppdiblc2=2.5416582e-017   pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.40932376           lkt1=1.4647807e-008
+ wkt1=7.4258093e-008       pkt1=-2.9695039e-014      kt1l=0
+ kt2=-0.058834644          lkt2=5.9743214e-009       wkt2=3.1656927e-009
+ pkt2=-4.3885964e-015      ute=-1.1257019            lute=-1.9819375e-008
+ wute=-2.2018155e-007      pute=7.0488653e-014       ua1=6.4118077e-009
+ lua1=-1.2602579e-015      wua1=-1.9465028e-015      pua1=6.6701582e-022
+ ub1=-8.8426282e-018       lub1=2.3605494e-024       wub1=2.0824651e-024
+ pub1=-7.140365e-031       uc1=-4.5054387e-011       luc1=-1.6304189e-017
+ wuc1=-3.0343419e-017      puc1=1.6520778e-023       prt=0
+ at=48679.901              lat=-0.0268879            wat=2.5198247e-005
+ pat=3.6599877e-009        tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           xgl=0
+ pvsat=0+dpvsatn_3m        fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     10: type=n 
+ lmin=1e-005-(dxln_3m+dlmisn_3m)                     lmax=900.01e-6
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50644736+(dvthn_3m+vthmisn_3m)
+ wvth0=1.1841371e-009+dwvthn_3m                      k1=0.75128
+ k2=0.014053677+dk2n_3m    wk2=-7.7507155e-009       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00029
+ voff=-0.12081936          wvoff=-2.0184155e-009     nfactor=0.84425807
+ wnfactor=2.6912207e-008   eta0=0.015450968          weta0=-9.4192723e-010
+ etab=-0.044               u0=0.044885161+du0n_3m    wu0=5.3824413e-010
+ ua=-1.0814097e-010        wua=-4.2857689e-017       ub=2.3290865e-018
+ wub=-2.8526939e-026       uc=1.2666192e-010         wuc=-6.7746097e-018
+ vsat=70000+dvsatn_3m      a0=1.2837776              wa0=-2.40326e-008
+ ags=0.31555742            wags=-2.6912207e-010      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.050667            dwg=0                     dwb=0
+ pclm=0.10327742           wpclm=8.0736619e-009      pdiblc1=0
+ pdiblc2=0.00020160516     wpdiblc2=8.8810281e-012   pdiblcb=0
+ drout=0.56                pvag=0.36                 delta=0.01
+ pscbe1=5e+008             pscbe2=1e-010             fprout=100
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=280                   rdw=280
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.1917e+009         cgidl=20                  egidl=0.9035
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3m              cgdo=cgon_3m              cgbo=0
+ cgdl=cgln_3m              cgsl=cgln_3m              clc=1e-007
+ cle=0.6                   cf=cfn_3m                 ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=5.5934
+ noff=1.631                voffcv=-0.052318          kt1=-0.25076779
+ wkt1=-4.6504293e-009      kt1l=0                    kt2=-0.053442581
+ wkt2=-2.6912207e-010      ute=-1.5122265            wute=3.2698331e-008
+ ua1=2.1657365e-009        wua1=-3.415159e-017       ub1=-3.7464675e-018
+ wub1=1.0600718e-025       uc1=-1.3345595e-010       wuc1=3.4259239e-018
+ prt=0                     at=150721.68              wat=-0.0023279059
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     lvth0=0+dlvthn_3m
+ pvth0=0+dpvthn_3m         saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           pvsat=0+dpvsatn_3m        lcit=0+dlcitn_3m
+ pcit=0+dpcitn_3m          fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     11: type=n 
+ lmin=1.2e-006-(dxln_3m+dlmisn_3m)                   lmax=1e-005-(dxln_3m+dlmisn_3m)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50531462+(dvthn_3m+vthmisn_3m)
+ lvth0=1.1264456e-008+dlvthn_3m                      wvth0=1.4735866e-009+dwvthn_3m
+ pvth0=-2.8784187e-015+dpvthn_3m                     k1=0.75128
+ k2=0.015123748+dk2n_3m    lk2=-1.0641269e-008       wk2=-7.8592153e-009
+ pk2=1.0789719e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=2                    dvt1=0.182
+ dvt2=0.0001               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2                  minv=-0.3
+ voffl=-2.6873e-010        dvtp0=3.6e-007            dvtp1=0.001
+ lpe0=1.8e-008             lpeb=1e-010               xj=1.4e-007
+ ngate=1.0051e+020         ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00029               voff=-0.11915984
+ lvoff=-1.6502971e-008     wvoff=-2.3173149e-009     pvoff=2.9723937e-015
+ nfactor=0.82400347        lnfactor=2.0142099e-007   wnfactor=3.04122e-008
+ pnfactor=-3.4805547e-014  eta0=0.015450968          weta0=-9.4192723e-010
+ etab=-0.044               u0=0.045087707+du0n_3m    lu0=-2.0142099e-009
+ wu0=5.0324419e-010        pu0=3.4805547e-016        ua=-8.8828922e-011
+ lua=-1.9204787e-016       wua=-3.3010107e-017       pua=-9.7928886e-023
+ ub=2.3964507e-018         lub=-6.699015e-025        wub=-4.0643917e-026
+ pub=1.204968e-031         uc=1.3043817e-010         luc=-3.7552764e-017
+ wuc=-6.4399053e-018       puc=-3.3284544e-024       vsat=70000+dvsatn_3m
+ a0=1.4153522              la0=-1.3084385e-006       wa0=-3.1231737e-008
+ pa0=7.1591529e-014        ags=0.30597047            lags=9.5337042e-008
+ wags=-1.811909e-008       pags=1.7750829e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.047525344         lketa=-3.1242071e-008     wketa=7.9950354e-010
+ pketa=-7.950631e-015      dwg=0                     dwb=0
+ pclm=0.077970086          lpclm=2.5166776e-007      wpclm=1.0873657e-008
+ ppclm=-2.7844437e-014     pdiblc1=0                 pdiblc2=0.00019787207
+ lpdiblc2=3.712354e-011    wpdiblc2=-5.0139465e-012  ppdiblc2=1.3817802e-016
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.24142837           lkt1=-9.2875567e-008      wkt1=-6.8953252e-009
+ pkt1=2.2324278e-014       kt1l=0                    kt2=-0.053928724
+ lkt2=4.8344374e-009       wkt2=2.8377393e-011       pkt2=-2.9584715e-015
+ ute=-1.508715             lute=-3.491909e-008       wute=3.2698331e-008
+ pute=-5.3798125e-029      ua1=2.0551746e-009        lua1=1.0994791e-015
+ wua1=-5.3291426e-018      pua1=-2.8662368e-022      ub1=-3.6407802e-018
+ lub1=-1.0510029e-024      wub1=6.9554748e-026       pub1=3.6249977e-031
+ uc1=-1.3756436e-010       luc1=4.0855936e-017       wuc1=3.2677242e-018
+ puc1=1.5732107e-024       prt=0                     at=166597.94
+ lat=-0.15788083           wat=-0.0028326049         pat=5.0189598e-009
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     pvsat=0+dpvsatn_3m
+ lcit=0+dlcitn_3m          saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           pcit=0+dpcitn_3m          fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     12: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-(dxln_3m+dlmisn_3m)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_3m+dwmisn_3m)
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3m+toxmisn_3m)
+ toxm=6.7e-009             dtox=5.4717e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-0.015e-6+(dxln_3m+dlmisn_3m)                    xw=0+(dxwn_3m+dwmisn_3m)
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.51751682+(dvthn_3m+vthmisn_3m)
+ lvth0=-2.7004766e-009+dlvthn_3m                     wvth0=-4.7217521e-009+dwvthn_3m
+ pvth0=4.2118986e-015+dpvthn_3m                      k1=0.75128
+ k2=0.01756084+dk2n_3m     lk2=-1.3430424e-008       wk2=-1.3326958e-008
+ pk2=7.3365851e-015        k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=2                    dvt1=0.182
+ dvt2=0.0001               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2                  minv=-0.3
+ voffl=-2.6873e-010        dvtp0=3.6e-007            dvtp1=0.001
+ lpe0=1.8e-008             lpeb=1e-010               xj=1.4e-007
+ ngate=1.0051e+020         ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00032453727        lcit=7.0331333e-010+dlcitn_3m
+ wcit=7.32631e-011         pcit=-8.3846687e-017+dpcitn_3m
+ voff=-0.1289464           lvoff=-5.3026488e-009     wvoff=-1.9570797e-009
+ pvoff=2.5601188e-015      nfactor=1.1919075         lnfactor=-2.1963047e-007
+ wnfactor=-4.8842066e-008  pnfactor=5.5897791e-014   eta0=0.015450968
+ weta0=-9.4192723e-010     etab=-0.044               u0=0.042122905+du0n_3m
+ lu0=1.3788881e-009        wu0=7.4735197e-011        pu0=8.3846687e-016
+ ua=7.5152658e-011         lua=-3.7971823e-016       wua=-9.4882144e-017
+ pua=-2.7118814e-023       ub=1.4610384e-018         lub=4.0064056e-025
+ wub=1.3771085e-025        pub=-8.3623096e-032       uc=8.4288849e-011
+ luc=1.5263285e-017        wuc=-4.7883287e-018       puc=-5.2186178e-024
+ vsat=70000+dvsatn_3m      a0=0.48552029             la0=-2.4428308e-007
+ wa0=5.2854115e-009        pa0=2.9799113e-014        ags=-0.4279937
+ lags=9.3532967e-007       wags=-2.6010287e-007      pags=4.5444904e-013
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.19044576          lketa=1.3232463e-007
+ wketa=6.7222264e-008      pketa=-8.3968824e-014     dwg=0
+ dwb=0                     pclm=0.29921748           lpclm=-1.5410314e-009
+ wpclm=-6.229817e-008      ppclm=5.5897791e-014      pdiblc1=0
+ pdiblc2=0.00026823454     lpdiblc2=-4.3403484e-011  wpdiblc2=1.7189086e-010
+ ppdiblc2=-6.428246e-017   pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.26512729           lkt1=-6.5753103e-008
+ wkt1=4.6400347e-009       pkt1=9.1225196e-015       kt1l=0
+ kt2=-0.039461671          lkt2=-1.1722527e-008      wkt2=-6.1875788e-009
+ pkt2=4.1554418e-015       ute=-1.6814475            lute=1.6276628e-007
+ wute=4.8132424e-008       pute=-1.7663702e-014      ua1=3.1733147e-009
+ lua1=-1.8018757e-016      wua1=-3.8295835e-016      pua1=1.4555785e-022
+ ub1=-5.5952994e-018       lub1=1.1858661e-024       wub1=5.1465476e-025
+ pub1=-1.468994e-031       uc1=-1.0158535e-010       luc1=-3.2060153e-019
+ wuc1=-3.0502699e-018      puc1=8.8039021e-024       prt=0
+ at=54331.23               lat=-0.029396073          wat=-0.0027032634
+ pat=4.8709335e-009        tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           xgl=0
+ pvsat=0+dpvsatn_3m        fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
     } 
ends mench3_mac
// 
 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V MED-Vt NMOS DEVICE MODELS          
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model mench3 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_3m       lmax=900.01e-6            wmin=1.003e-005-dxwn_3m
+ wmax=900.04e-6            version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.4928+dvthn_3m      k1=0.75128
+ k2=0.0011+dk2n_3m         k3=-2.584                 k3b=1.844e-010
+ w0=0                      dvt0=2                    dvt1=0.182
+ dvt2=0.0001               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2                  minv=-0.3
+ voffl=-2.6873e-010        dvtp0=3.6e-007            dvtp1=0.001
+ lpe0=1.8e-008             lpeb=1e-010               xj=1.4e-007
+ ngate=1.0051e+020         ndep=3e+017               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00025               voff=-0.126
+ nfactor=0.913             eta0=0.028                etab=-0.044
+ u0=0.046+du0n_3m          ua=-3.0802e-010           ub=2.77e-018
+ uc=1.4085e-010            vsat=70000+dvsatn_3m      a0=1.1698
+ ags=0.3356                a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.045646
+ dwg=0                     dwb=0                     pclm=0.178
+ pdiblc1=0                 pdiblc2=0.0002            pdiblcb=0
+ drout=0.56                pvag=0.36                 delta=0.01
+ pscbe1=5e+008             pscbe2=1e-010             fprout=100
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=280                   rdw=280
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.1917e+009         cgidl=20                  egidl=0.9035
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3m              cgdo=cgon_3m              cgbo=0
+ cgdl=cgln_3m              cgsl=cgln_3m              clc=1e-007
+ cle=0.6                   cf=cfn_3m                 ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=5.5934
+ noff=1.631                voffcv=-0.052318          kt1=-0.28364
+ kt1l=0                    kt2=-0.045                ute=-1.2203
+ ua1=2.4158e-009           ub1=-2.0096e-018          uc1=-6.194e-011
+ prt=0                     at=150000                 tnoimod=0
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3m                cjd=cjn_3m                mjs=0.325
+ mjd=0.325                 pbsws=0.630               pbswd=0.630
+ cjsws=cjswn_3m            cjswd=cjswn_3m            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3m          cjswgd=cjswgn_3m          mjswgs=0.410
+ mjswgd=0.410              tpb=0.0017                tcj=0.00092
+ tpbsw=0.00175             tcjsw=0.000769            tpbswg=0.00146
+ tcjswg=0.0011             xtis=3                    xtid=3
+ jtsswgs=1e-010            jtsswgd=1e-010            njtsswg=45
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3m         wvth0=0+dwvthn_3m
+ pvth0=0+dpvthn_3m         pvsat=0+dpvsatn_3m        saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           lcit=0+dlcitn_3m
+ pcit=0+dpcitn_3m          fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     2: type=n 
+ lmin=1.2e-006-dxln_3m     lmax=1e-005-dxln_3m       wmin=1.003e-005-dxwn_3m
+ wmax=900.04e-6            version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.49082321+dvthn_3m  lvth0=1.9658154e-008+dlvthn_3m
+ k1=0.75128                k2=0.0020975009+dk2n_3m   lk2=-9.9196081e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=2                    dvt1=0.182                dvt2=0.0001
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.2                  minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=3.6e-007            dvtp1=0.001               lpe0=1.8e-008
+ lpeb=1e-010               xj=1.4e-007               ngate=1.0051e+020
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00025               voff=-0.12593497          lvoff=-6.4664981e-010
+ nfactor=0.92119329        lnfactor=-8.1477876e-008  eta0=0.028
+ etab=-0.044               u0=0.046+du0n_3m          ua=-2.6984836e-010
+ lua=-3.7959637e-016       ub=2.797441e-018          lub=-2.7288622e-025
+ uc=1.4363182e-010         luc=-2.7663679e-017       vsat=70000+dvsatn_3m
+ a0=1.2654443              la0=-9.5113134e-007       ags=0.32852516
+ lags=7.03555e-008         a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.04226165
+ lketa=-3.3655536e-008     dwg=0                     dwb=0
+ pclm=0.17292796           lpclm=5.0438685e-008      pdiblc1=0
+ pdiblc2=0.00018400357     lpdiblc2=1.5907585e-010   pdiblcb=0
+ drout=0.56                pvag=0.36                 delta=0.01
+ pscbe1=5e+008             pscbe2=1e-010             fprout=100
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=280                   rdw=280
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.1917e+009         cgidl=20                  egidl=0.9035
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3m              cgdo=cgon_3m              cgbo=0
+ cgdl=cgln_3m              cgsl=cgln_3m              clc=1e-007
+ cle=0.6                   cf=cfn_3m                 ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=5.5934
+ noff=1.631                voffcv=-0.052318          kt1=-0.28146162
+ lkt1=-2.1662769e-008      kt1l=0                    kt2=-0.045
+ ute=-1.2280121            lute=7.6692668e-008       ua1=2.3398625e-009
+ lua1=7.5515765e-016       ub1=-1.9531963e-018       lub1=-5.6090405e-025
+ uc1=-7.1088072e-011       luc1=9.0972636e-017       prt=0
+ at=168207.32              lat=-0.18106195           tnoimod=0
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3m                cjd=cjn_3m                mjs=0.325
+ mjd=0.325                 pbsws=0.630               pbswd=0.630
+ cjsws=cjswn_3m            cjswd=cjswn_3m            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3m          cjswgd=cjswgn_3m          mjswgs=0.410
+ mjswgd=0.410              tpb=0.0017                tcj=0.00092
+ tpbsw=0.00175             tcjsw=0.000769            tpbswg=0.00146
+ tcjswg=0.0011             xtis=3                    xtid=3
+ jtsswgs=1e-010            jtsswgd=1e-010            njtsswg=45
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     wvth0=0+dwvthn_3m         pvth0=0+dpvthn_3m
+ pvsat=0+dpvsatn_3m        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           lcit=0+dlcitn_3m          pcit=0+dpcitn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     3: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-dxln_3m     wmin=1.003e-005-dxwn_3m
+ wmax=900.04e-6            version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50718331+dvthn_3m  lvth0=9.3466904e-010+dlvthn_3m
+ k1=0.75128                k2=-0.005726087+dk2n_3m   lk2=-9.6582467e-010
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=2                    dvt1=0.182                dvt2=0.0001
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.2                  minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=3.6e-007            dvtp1=0.001               lpe0=1.8e-008
+ lpeb=1e-010               xj=1.4e-007               ngate=1.0051e+020
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00020462833         lcit=5.1926058e-011+dlcitn_3m
+ voff=-0.13421318          lvoff=8.8274298e-009      nfactor=0.713885
+ lnfactor=1.5577817e-007   eta0=0.028                etab=-0.044
+ u0=0.0405554+du0n_3m      lu0=6.2311269e-009        ua=-2.4221362e-010
+ lua=-4.1122322e-016       ub=2.201925e-018          lub=4.0865807e-025
+ uc=1.0305361e-010         luc=1.8776462e-017        vsat=70000+dvsatn_3m
+ a0=0.37974251             la0=6.2518973e-008        ags=0.6431739
+ lags=-2.897474e-007       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.06353386
+ lketa=-9.3103421e-009     dwg=0                     dwb=0
+ pclm=0.1734432            lpclm=4.9849015e-008      pdiblc1=0
+ pdiblc2=0.00034387097     lpdiblc2=-2.3885987e-011  pdiblcb=0
+ drout=0.56                pvag=0.36                 delta=0.01
+ pscbe1=5e+008             pscbe2=1e-010             fprout=100
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.3875                rsw=280                   rdw=280
+ rdwmin=1e-006             rswmin=1e-006             prwg=0
+ prwb=0                    wr=1                      alpha0=1.06e-6
+ alpha1=8.868              beta0=21.1                agidl=1.53e-009
+ bgidl=2.1917e+009         cgidl=20                  egidl=0.9035
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_3m              cgdo=cgon_3m              cgbo=0
+ cgdl=cgln_3m              cgsl=cgln_3m              clc=1e-007
+ cle=0.6                   cf=cfn_3m                 ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=5.5934
+ noff=1.631                voffcv=-0.052318          kt1=-0.31417391
+ lkt1=1.5775136e-008       kt1l=0                    kt2=-0.0422777
+ lkt2=-3.1155635e-009      ute=-1.4629484            lute=3.4556791e-007
+ ua1=3.7501474e-009        lua1=-8.5885699e-016      ub1=-4.7363432e-018
+ lub1=2.6242962e-024       uc1=-1.5249414e-010       luc1=1.8413863e-016
+ prt=0                     at=14537.167              lat=-0.0051926058
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     wvth0=0+dwvthn_3m
+ pvth0=0+dpvthn_3m         pvsat=0+dpvsatn_3m        saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           pcit=0+dpcitn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     4: type=n 
+ lmin=1e-005-dxln_3m       lmax=900.01e-6            wmin=1.23e-006-dxwn_3m
+ wmax=1.003e-005-dxwn_3m   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.49089139+dvthn_3m  wvth0=1.9053263e-008+dwvthn_3m
+ k1=0.75128                k2=0.00076397727+dk2n_3m  wk2=3.3544477e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=2                    dvt1=0.182                dvt2=0.0001
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.2                  minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=3.6e-007            dvtp1=0.001               lpe0=1.8e-008
+ lpeb=1e-010               xj=1.4e-007               ngate=1.0051e+020
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00024462364         wcit=5.3671163e-011       voff=-0.12634946
+ wvoff=3.4886256e-009      nfactor=0.90130641        wnfactor=1.1673478e-007
+ eta0=0.028336023          weta0=-3.3544477e-009     etab=-0.044
+ u0=0.046134409+du0n_3m    wu0=-1.3417791e-009       ua=-3.4013625e-010
+ wua=3.2061006e-016        ub=2.8545433e-018         wub=-8.4397904e-025
+ uc=1.43932e-010           wuc=-3.0766994e-017       vsat=70000+dvsatn_3m
+ a0=1.1815339              wa0=-1.1713731e-007       ags=0.33897367
+ wags=-3.3678655e-008      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.045646
+ dwg=0                     dwb=0                     pclm=0.18579573
+ wpclm=-7.7823186e-008     pdiblc1=0                 pdiblc2=0.00020403227
+ wpdiblc2=-4.0253372e-011  pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.28402172           wkt1=3.8106526e-009
+ kt1l=0                    kt2=-0.042715046          wkt2=-2.2810244e-008
+ ute=-1.2157839            wute=-4.5083777e-008      ua1=2.2686221e-009
+ wua1=1.4692481e-015       ub1=-1.6409159e-018       wub1=-3.6805e-024
+ uc1=-5.3632174e-011       wuc1=-8.2935365e-017      prt=0
+ at=150106.18              wat=-0.0010600055         tnoimod=0
+ jss=3.93e-07              jsd=3.93e-07              jsws=1.43e-12
+ jswd=1.43e-12             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.04                 bvd=11.04                 xjbvs=1
+ xjbvd=1                   pbs=0.707                 pbd=0.707
+ cjs=cjn_3m                cjd=cjn_3m                mjs=0.325
+ mjd=0.325                 pbsws=0.630               pbswd=0.630
+ cjsws=cjswn_3m            cjswd=cjswn_3m            mjsws=0.204
+ mjswd=0.204               pbswgs=0.707              pbswgd=0.707
+ cjswgs=cjswgn_3m          cjswgd=cjswgn_3m          mjswgs=0.410
+ mjswgd=0.410              tpb=0.0017                tcj=0.00092
+ tpbsw=0.00175             tcjsw=0.000769            tpbswg=0.00146
+ tcjswg=0.0011             xtis=3                    xtid=3
+ jtsswgs=1e-010            jtsswgd=1e-010            njtsswg=45
+ dmcg=2.05e-7              dmci=3.15e-7              dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     lvth0=0+dlvthn_3m         pvth0=0+dpvthn_3m
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.35
+ wlod=3.00e-07             tku0=0.03                 ku0=-5.50e-08
+ llodku0=1                 wlodku0=1                 lku0=1.49e-07
+ wku0=5.00e-06             pku0=0.00e+00             kvth0=3.20e-10
+ stk2=0.00e+00             steta0=-1.10e-10          lkvth0=-1.80e-07
+ wkvth0=2.00e-06           pkvth0=0.00e+00           llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wec=0                     web=0                     scref=1.00e-06
+ wpemod=1                  kvth0we=4.50e-03          pkvth0we=-9.00e-17
+ wkvth0we=1.00e-10         lkvth0we=9.30e-10         ku0we=0
+ pku0we=0                  wku0we=0                  lku0we=0
+ k2we=4.60e-03             lk2we=8.50e-10            wk2we=-1.50e-10
+ pvsat=0+dpvsatn_3m        lcit=0+dlcitn_3m          pcit=0+dpcitn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     5: type=n 
+ lmin=1.2e-006-dxln_3m     lmax=1e-005-dxln_3m       wmin=1.23e-006-dxwn_3m
+ wmax=1.003e-005-dxwn_3m   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.48877476+dvthn_3m  lvth0=2.1048804e-008+dlvthn_3m
+ wvth0=2.0449274e-008+dwvthn_3m                      pvth0=-1.3882579e-014+dpvthn_3m
+ k1=0.75128                k2=0.0017920686+dk2n_3m   lk2=-1.0223813e-008
+ wk2=3.0490702e-009        pk2=3.0368142e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00024715827
+ lcit=-2.5205528e-011+dlcitn_3m                      wcit=2.8368457e-011
+ pcit=2.5162174e-016+dpcitn_3m                       voff=-0.12637359
+ lvoff=2.3988944e-010      wvoff=4.3785828e-009      pvoff=-8.8501441e-015
+ nfactor=0.91060096        lnfactor=-9.2429244e-008  wnfactor=1.0574119e-007
+ pnfactor=1.0932531e-013   eta0=0.028336023          weta0=-3.3544477e-009
+ etab=-0.044               u0=0.046134409+du0n_3m    wu0=-1.3417791e-009
+ ua=-3.0159007e-010        lua=-3.8332088e-016       wua=3.1687119e-016
+ pua=3.7181017e-023        ub=2.8825962e-018         lub=-2.7897031e-025
+ wub=-8.5008659e-025       pub=6.0736283e-032        uc=1.4686502e-010
+ luc=-2.9167319e-017       wuc=-3.2276431e-017       puc=1.5010539e-023
+ vsat=70000+dvsatn_3m      a0=1.2764074              la0=-9.4346539e-007
+ wa0=-1.094418e-007        pa0=-7.6527717e-014       ags=0.33551898
+ lags=3.4355053e-008       wags=-6.9817898e-008      pags=3.5938526e-013
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.042430037         lketa=-3.198102e-008
+ wketa=1.6809722e-009      pketa=-1.671636e-014      dwg=0
+ dwb=0                     pclm=0.18144038           lpclm=4.3311605e-008
+ wpclm=-8.4977744e-008     ppclm=7.1148217e-014      pdiblc1=0
+ pdiblc2=0.00019165425     lpdiblc2=1.2309279e-010   wpdiblc2=-7.6375166e-011
+ ppdiblc2=3.5921173e-016   pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.28285947           lkt1=-1.155796e-008
+ wkt1=1.395442e-008        pkt1=-1.0087429e-013      kt1l=0
+ kt2=-0.04257835           lkt2=-1.3593602e-009      wkt2=-2.4174845e-008
+ pkt2=1.3570221e-014       ute=-1.2249381            lute=9.1033744e-008
+ wute=-3.068741e-008       pute=-1.431641e-013       ua1=2.1937858e-009
+ lua1=7.4420628e-016       wua1=1.4582545e-015       pua1=1.0932531e-022
+ ub1=-1.5908156e-018       lub1=-4.9822051e-025      wub1=-3.6175748e-024
+ pub1=-6.2575725e-031      uc1=-6.311834e-011        luc1=9.4334792e-017
+ wuc1=-7.9560245e-017      puc1=-3.3563738e-023      prt=0
+ at=168640.4               lat=-0.18431277           wat=-0.0043233565
+ pat=3.2452264e-008        tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           xgw=0                     xgl=0
+ pvsat=0+dpvsatn_3m        fnoimod=1                 noia=noian_3m
+ noib=noibn_3m             noic=noicn_3m             em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     6: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-dxln_3m     wmin=1.23e-006-dxwn_3m
+ wmax=1.003e-005-dxwn_3m   version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50654512+dvthn_3m  lvth0=7.1133034e-010+dlvthn_3m
+ wvth0=6.3709102e-009+dwvthn_3m                      pvth0=2.2295455e-015+dpvthn_3m
+ k1=0.75128                k2=-0.00616926+dk2n_3m    lk2=-1.1123907e-009
+ wk2=4.4241073e-009        pk2=1.4631393e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0002009191
+ lcit=2.7713351e-011+dlcitn_3m                       wcit=3.7028559e-011
+ pcit=2.417106e-016+dpcitn_3m                        voff=-0.13418208
+ lvoff=9.1763965e-009      wvoff=-3.1051004e-010     pvoff=-3.4836649e-015
+ nfactor=0.67542854        lnfactor=1.7671618e-007   wnfactor=3.8390312e-007
+ pnfactor=-2.0901989e-013  eta0=0.028336023          weta0=-3.3544477e-009
+ etab=-0.044               u0=0.04020194+du0n_3m     lu0=6.7894737e-009
+ wu0=3.5285212e-009        pu0=-5.5738638e-015       ua=-2.9021509e-010
+ lua=-3.9633909e-016       wua=4.7918905e-016        pua=-1.4858527e-022
+ ub=2.2599318e-018         lub=4.3364409e-025        wub=-5.7907083e-025
+ pub=-2.4943041e-031       uc=1.0376549e-010         luc=2.0158371e-017
+ wuc=-7.1066121e-018       puc=-1.3795313e-023       vsat=70000+dvsatn_3m
+ a0=0.37940394             la0=8.3119176e-008        wa0=3.3799567e-009
+ pa0=-2.0564771e-013       ags=0.66835213            lags=-3.4655918e-007
+ wags=-2.5134926e-007      pags=5.6714064e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.061145661         lketa=-1.0561737e-008     wketa=-2.3840918e-008
+ pketa=1.2492422e-014      dwg=0                     dwb=0
+ pclm=0.18207045           lpclm=4.2590508e-008      wpclm=-8.6124147e-008
+ ppclm=7.2460229e-014      pdiblc1=0                 pdiblc2=0.00029849235
+ lpdiblc2=8.2085656e-013   wpdiblc2=4.5300568e-010   ppdiblc2=-2.4664347e-016
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.30982333           lkt1=1.9301096e-008       wkt1=-4.3431019e-008
+ pkt1=-3.519895e-014       kt1l=0                    kt2=-0.040412034
+ lkt2=-3.8386225e-009      wkt2=-1.8624571e-008      pkt2=7.2181536e-015
+ ute=-1.4832568            lute=3.8666921e-007       wute=2.0273443e-007
+ pute=-4.1030605e-013      ua1=3.6135895e-009        lua1=-8.8070231e-016
+ wua1=1.3632297e-015       pua1=2.1807742e-022       ub1=-4.4210649e-018
+ lub1=2.7408867e-024       wub1=-3.1473599e-024      pub1=-1.1638994e-030
+ uc1=-1.6348691e-010       luc1=2.092026e-016        wuc1=1.0973857e-016
+ puc1=-2.5020866e-022      prt=0                     at=9945.2093
+ lat=-0.0026924687         wat=0.045840592           pat=-2.4958369e-008
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           xgl=0                     pvsat=0+dpvsatn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=1e-005-dxln_3m       lmax=900.01e-6            wmin=5.3e-007-dxwn_3m
+ wmax=1.23e-006-dxwn_3m    version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50568954+dvthn_3m  wvth0=1.5500087e-009+dwvthn_3m
+ k1=0.75128                k2=0.0074624+dk2n_3m      wk2=-4.5684467e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=2                    dvt1=0.182                dvt2=0.0001
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.2                  minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=3.6e-007            dvtp1=0.001               lpe0=1.8e-008
+ lpeb=1e-010               xj=1.4e-007               ngate=1.0051e+020
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00029               voff=-0.12229646          wvoff=-1.3052705e-009
+ nfactor=1.0689714         wnfactor=-8.1579406e-008  eta0=0.033776571
+ weta0=-9.7895287e-009     etab=-0.044               u0=0.044310286+du0n_3m
+ wu0=8.1579406e-010        ua=1.9092936e-011         wua=-1.0428622e-016
+ ub=2.0520269e-018         wub=1.0523743e-025        uc=1.2156859e-010
+ wuc=-4.3155506e-018       vsat=70000+dvsatn_3m      a0=0.97800829
+ wa0=1.235928e-007         ags=0.30739629            wags=3.6710733e-009
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.042182945         wketa=-4.096102e-009
+ dwg=0                     dwb=0                     pclm=0.12
+ pdiblc1=0                 pdiblc2=0.00013551429     wpdiblc2=4.0789703e-011
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.29487017           wkt1=1.6642199e-008       kt1l=0
+ kt2=-0.067517714          wkt2=6.5263525e-009       ute=-1.1224405
+ wute=-1.5549035e-007      ua1=4.4872975e-009        wua1=-1.1550012e-015
+ ub1=-5.5979828e-018       wub1=9.9991878e-025       uc1=-1.2194985e-010
+ wuc1=-2.1292225e-018      prt=0                     at=151492.95
+ wat=-0.0027002783         tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3m         pvth0=0+dpvthn_3m         saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           pvsat=0+dpvsatn_3m
+ lcit=0+dlcitn_3m          pcit=0+dpcitn_3m          fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     8: type=n 
+ lmin=1.2e-006-dxln_3m     lmax=1e-005-dxln_3m       wmin=5.3e-007-dxwn_3m
+ wmax=1.23e-006-dxwn_3m    version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.5044751+dvthn_3m   lvth0=1.207698e-008+dlvthn_3m
+ wvth0=1.8789059e-009+dwvthn_3m                      pvth0=-3.2707051e-015+dpvthn_3m
+ k1=0.75128                k2=0.0081802841+dk2n_3m   lk2=-7.1389696e-009
+ wk2=-4.5069111e-009       pk2=-6.1193837e-016       k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00025813608
+ lcit=3.1686949e-010+dlcitn_3m                       wcit=1.5383901e-011
+ pcit=-1.5298459e-016+dpcitn_3m                      voff=-0.12178344
+ lvoff=-5.1016606e-009     wvoff=-1.0506404e-009     pvoff=-2.5321588e-015
+ nfactor=1.0779413         lnfactor=-8.9200723e-008  wnfactor=-9.2188993e-008
+ pnfactor=1.0550662e-013   eta0=0.033776571          weta0=-9.7895287e-009
+ etab=-0.044               u0=0.044220587+du0n_3m    lu0=8.9200723e-010
+ wu0=9.2188993e-010        pu0=-1.0550662e-015       ua=5.1495949e-011
+ lua=-3.2223046e-016       wua=-1.0075895e-016       pua=-3.5076729e-023
+ ub=2.0615509e-018         lub=-9.4711657e-026       wub=1.2104572e-025
+ pub=-1.5720486e-031       uc=1.2128554e-010         luc=2.8148031e-018
+ wuc=-2.0210152e-018       puc=-2.2817916e-023       vsat=70000+dvsatn_3m
+ a0=1.0688465              la0=-9.0333717e-007       wa0=1.3606119e-007
+ pa0=-1.2399137e-013       ags=0.28204356            lags=2.5211915e-007
+ wags=-6.5671783e-009      pags=1.0181388e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.037656489         lketa=-4.5013155e-008     wketa=-3.9651797e-009
+ pketa=-1.3019516e-015     dwg=0                     dwb=0
+ pclm=0.11587474           lpclm=4.1023464e-008      wpclm=-7.426711e-009
+ ppclm=7.385463e-014       pdiblc1=0                 pdiblc2=8.5421123e-005
+ lpdiblc2=4.9814945e-010   wpdiblc2=4.9277373e-011   ppdiblc2=-8.4405292e-017
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.28164975           lkt1=-1.3147e-007         wkt1=1.2523557e-008
+ pkt1=4.0957668e-014       kt1l=0                    kt2=-0.069325867
+ lkt2=1.7981107e-008       wkt2=7.462118e-009        pkt2=-9.3056834e-015
+ ute=-1.1197641            lute=-2.6614924e-008      wute=-1.5508718e-007
+ pute=-4.0092514e-015      ua1=4.3802217e-009        lua1=1.064811e-015
+ wua1=-1.1278619e-015      pua1=-2.6988592e-022      ub1=-5.4442536e-018
+ lub1=-1.5287544e-024      wub1=9.4027168e-025       pub1=5.9315819e-031
+ uc1=-1.3009753e-010       luc1=8.1024283e-017       wuc1=-3.3726322e-019
+ puc1=-1.7820067e-023      prt=0                     at=167919.47
+ lat=-0.16335282           wat=-0.0034706405         pat=7.6608353e-009
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           xgl=0                     pvsat=0+dpvsatn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     9: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-dxln_3m     wmin=5.3e-007-dxwn_3m
+ wmax=1.23e-006-dxwn_3m    version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.51482444+dvthn_3m  lvth0=2.3256939e-010+dlvthn_3m
+ wvth0=-3.4218727e-009+dwvthn_3m                     pvth0=2.795824e-015+dpvthn_3m
+ k1=0.75128                k2=0.0028224165+dk2n_3m   lk2=-1.0071044e-009
+ wk2=-6.2112477e-009       pk2=1.3386066e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00051157023
+ lcit=2.6824242e-011+dlcitn_3m                       wcit=-3.304096e-010
+ pcit=2.4276224e-016+dpcitn_3m                       voff=-0.13544096
+ lvoff=1.0528824e-008      wvoff=1.1784961e-009      pvoff=-5.0833163e-015
+ nfactor=0.93741303        lnfactor=7.1628288e-008   wnfactor=7.4027872e-008
+ pnfactor=-8.4721939e-014  eta0=0.033776571          weta0=-9.7895287e-009
+ etab=-0.044               u0=0.043811003+du0n_3m    lu0=1.3607594e-009
+ wu0=-7.4027872e-010       pu0=8.4721939e-016        ua=2.7788725e-010
+ lua=-5.8132626e-016       wua=-1.9276241e-016       pua=7.0217543e-023
+ ub=1.7869663e-018         lub=2.1953951e-025        wub=-1.9647135e-026
+ pub=3.8124872e-033        uc=1.1388698e-010         luc=1.128216e-017
+ wuc=-1.9078304e-017       puc=-3.2965306e-024       vsat=70000+dvsatn_3m
+ a0=0.30349189             la0=-2.7419409e-008       wa0=9.3168724e-008
+ pa0=-7.4902666e-014       ags=1.4370227             lags=-1.0697082e-006
+ wags=-1.1605328e-006      pags=1.4224814e-012       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.1020558           lketa=2.8689278e-008      wketa=2.4547592e-008
+ pketa=-3.3933678e-014     dwg=0                     dwb=0
+ pclm=0.067235364          lpclm=9.6689287e-008      wpclm=4.9702797e-008
+ ppclm=8.4721939e-015      pdiblc1=0                 pdiblc2=0.00072095419
+ lpdiblc2=-2.2919272e-010  wpdiblc2=-4.6682183e-011  ppdiblc2=2.5416582e-017
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.40932376           lkt1=1.4647807e-008       wkt1=7.4258093e-008
+ pkt1=-2.9695039e-014      kt1l=0                    kt2=-0.058834644
+ lkt2=5.9743214e-009       wkt2=3.1656927e-009       pkt2=-4.3885964e-015
+ ute=-1.1257019            lute=-1.9819375e-008      wute=-2.2018155e-007
+ pute=7.0488653e-014       ua1=6.4118077e-009        lua1=-1.2602579e-015
+ wua1=-1.9465028e-015      pua1=6.6701582e-022       ub1=-8.8426282e-018
+ lub1=2.3605494e-024       wub1=2.0824651e-024       pub1=-7.140365e-031
+ uc1=-4.5054387e-011       luc1=-1.6304189e-017      wuc1=-3.0343419e-017
+ puc1=1.6520778e-023       prt=0                     at=48679.901
+ lat=-0.0268879            wat=2.5198247e-005        pat=3.6599877e-009
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           xgl=0                     pvsat=0+dpvsatn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     10: type=n 
+ lmin=1e-005-dxln_3m       lmax=900.01e-6            wmin=2.2e-007
+ wmax=5.3e-007-dxwn_3m     version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50644736+dvthn_3m  wvth0=1.1841371e-009+dwvthn_3m
+ k1=0.75128                k2=0.014053677+dk2n_3m    wk2=-7.7507155e-009
+ k3=-2.584                 k3b=1.844e-010            w0=0
+ dvt0=2                    dvt1=0.182                dvt2=0.0001
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.2                  minv=-0.3                 voffl=-2.6873e-010
+ dvtp0=3.6e-007            dvtp1=0.001               lpe0=1.8e-008
+ lpeb=1e-010               xj=1.4e-007               ngate=1.0051e+020
+ ndep=3e+017               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00029               voff=-0.12081936          wvoff=-2.0184155e-009
+ nfactor=0.84425807        wnfactor=2.6912207e-008   eta0=0.015450968
+ weta0=-9.4192723e-010     etab=-0.044               u0=0.044885161+du0n_3m
+ wu0=5.3824413e-010        ua=-1.0814097e-010        wua=-4.2857689e-017
+ ub=2.3290865e-018         wub=-2.8526939e-026       uc=1.2666192e-010
+ wuc=-6.7746097e-018       vsat=70000+dvsatn_3m      a0=1.2837776
+ wa0=-2.40326e-008         ags=0.31555742            wags=-2.6912207e-010
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.050667            dwg=0
+ dwb=0                     pclm=0.10327742           wpclm=8.0736619e-009
+ pdiblc1=0                 pdiblc2=0.00020160516     wpdiblc2=8.8810281e-012
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.25076779           wkt1=-4.6504293e-009      kt1l=0
+ kt2=-0.053442581          wkt2=-2.6912207e-010      ute=-1.5122265
+ wute=3.2698331e-008       ua1=2.1657365e-009        wua1=-3.415159e-017
+ ub1=-3.7464675e-018       wub1=1.0600718e-025       uc1=-1.3345595e-010
+ wuc1=3.4259239e-018       prt=0                     at=150721.68
+ wat=-0.0023279059         tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ lvth0=0+dlvthn_3m         pvth0=0+dpvthn_3m         saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           pvsat=0+dpvsatn_3m
+ lcit=0+dlcitn_3m          pcit=0+dpcitn_3m          fnoimod=1
+ noia=noian_3m             noib=noibn_3m             noic=noicn_3m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     11: type=n 
+ lmin=1.2e-006-dxln_3m     lmax=1e-005-dxln_3m       wmin=2.2e-007
+ wmax=5.3e-007-dxwn_3m     version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.50531462+dvthn_3m  lvth0=1.1264456e-008+dlvthn_3m
+ wvth0=1.4735866e-009+dwvthn_3m                      pvth0=-2.8784187e-015+dpvthn_3m
+ k1=0.75128                k2=0.015123748+dk2n_3m    lk2=-1.0641269e-008
+ wk2=-7.8592153e-009       pk2=1.0789719e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00029
+ voff=-0.11915984          lvoff=-1.6502971e-008     wvoff=-2.3173149e-009
+ pvoff=2.9723937e-015      nfactor=0.82400347        lnfactor=2.0142099e-007
+ wnfactor=3.04122e-008     pnfactor=-3.4805547e-014  eta0=0.015450968
+ weta0=-9.4192723e-010     etab=-0.044               u0=0.045087707+du0n_3m
+ lu0=-2.0142099e-009       wu0=5.0324419e-010        pu0=3.4805547e-016
+ ua=-8.8828922e-011        lua=-1.9204787e-016       wua=-3.3010107e-017
+ pua=-9.7928886e-023       ub=2.3964507e-018         lub=-6.699015e-025
+ wub=-4.0643917e-026       pub=1.204968e-031         uc=1.3043817e-010
+ luc=-3.7552764e-017       wuc=-6.4399053e-018       puc=-3.3284544e-024
+ vsat=70000+dvsatn_3m      a0=1.4153522              la0=-1.3084385e-006
+ wa0=-3.1231737e-008       pa0=7.1591529e-014        ags=0.30597047
+ lags=9.5337042e-008       wags=-1.811909e-008       pags=1.7750829e-013
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.047525344         lketa=-3.1242071e-008
+ wketa=7.9950354e-010      pketa=-7.950631e-015      dwg=0
+ dwb=0                     pclm=0.077970086          lpclm=2.5166776e-007
+ wpclm=1.0873657e-008      ppclm=-2.7844437e-014     pdiblc1=0
+ pdiblc2=0.00019787207     lpdiblc2=3.712354e-011    wpdiblc2=-5.0139465e-012
+ ppdiblc2=1.3817802e-016   pdiblcb=0                 drout=0.56
+ pvag=0.36                 delta=0.01                pscbe1=5e+008
+ pscbe2=1e-010             fprout=100                pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.3875
+ rsw=280                   rdw=280                   rdwmin=1e-006
+ rswmin=1e-006             prwg=0                    prwb=0
+ wr=1                      alpha0=1.06e-6            alpha1=8.868
+ beta0=21.1                agidl=1.53e-009           bgidl=2.1917e+009
+ cgidl=20                  egidl=0.9035              aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_3m
+ cgdo=cgon_3m              cgbo=0                    cgdl=cgln_3m
+ cgsl=cgln_3m              clc=1e-007                cle=0.6
+ cf=cfn_3m                 ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=5.5934               noff=1.631
+ voffcv=-0.052318          kt1=-0.24142837           lkt1=-9.2875567e-008
+ wkt1=-6.8953252e-009      pkt1=2.2324278e-014       kt1l=0
+ kt2=-0.053928724          lkt2=4.8344374e-009       wkt2=2.8377393e-011
+ pkt2=-2.9584715e-015      ute=-1.508715             lute=-3.491909e-008
+ wute=3.2698331e-008       pute=-5.3798125e-029      ua1=2.0551746e-009
+ lua1=1.0994791e-015       wua1=-5.3291426e-018      pua1=-2.8662368e-022
+ ub1=-3.6407802e-018       lub1=-1.0510029e-024      wub1=6.9554748e-026
+ pub1=3.6249977e-031       uc1=-1.3756436e-010       luc1=4.0855936e-017
+ wuc1=3.2677242e-018       puc1=1.5732107e-024       prt=0
+ at=166597.94              lat=-0.15788083           wat=-0.0028326049
+ pat=5.0189598e-009        tnoimod=0                 jss=3.93e-07
+ jsd=3.93e-07              jsws=1.43e-12             jswd=1.43e-12
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.04
+ bvd=11.04                 xjbvs=1                   xjbvd=1
+ pbs=0.707                 pbd=0.707                 cjs=cjn_3m
+ cjd=cjn_3m                mjs=0.325                 mjd=0.325
+ pbsws=0.630               pbswd=0.630               cjsws=cjswn_3m
+ cjswd=cjswn_3m            mjsws=0.204               mjswd=0.204
+ pbswgs=0.707              pbswgd=0.707              cjswgs=cjswgn_3m
+ cjswgd=cjswgn_3m          mjswgs=0.410              mjswgd=0.410
+ tpb=0.0017                tcj=0.00092               tpbsw=0.00175
+ tcjsw=0.000769            tpbswg=0.00146            tcjswg=0.0011
+ xtis=3                    xtid=3                    jtsswgs=1e-010
+ jtsswgd=1e-010            njtsswg=45                dmcg=2.05e-7
+ dmci=3.15e-7              dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ pvsat=0+dpvsatn_3m        lcit=0+dlcitn_3m          saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.35                wlod=3.00e-07
+ tku0=0.03                 ku0=-5.50e-08             llodku0=1
+ wlodku0=1                 lku0=1.49e-07             wku0=5.00e-06
+ pku0=0.00e+00             kvth0=3.20e-10            stk2=0.00e+00
+ steta0=-1.10e-10          lkvth0=-1.80e-07          wkvth0=2.00e-06
+ pkvth0=0.00e+00           llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wec=0
+ web=0                     scref=1.00e-06            wpemod=1
+ kvth0we=4.50e-03          pkvth0we=-9.00e-17        wkvth0we=1.00e-10
+ lkvth0we=9.30e-10         ku0we=0                   pku0we=0
+ wku0we=0                  lku0we=0                  k2we=4.60e-03
+ lk2we=8.50e-10            wk2we=-1.50e-10           pcit=0+dpcitn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     12: type=n 
+ lmin=6.0e-007             lmax=1.2e-006-dxln_3m     wmin=2.2e-007
+ wmax=5.3e-007-dxwn_3m     version=4.5               gbmin=1.00e-12
+ tempmod=0                 rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=1                    rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=toxn_3m              toxm=6.7e-009             dtox=5.4717e-010
+ epsrox=3.9                wint=2.36e-008            lint=2.027e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-0.015e-6+dxln_3m      xw=0+dxwn_3m
+ dlc=dlcn_3m               dwc=0                     xpart=1
+ toxref=3e-009             vth0=0.51751682+dvthn_3m  lvth0=-2.7004766e-009+dlvthn_3m
+ wvth0=-4.7217521e-009+dwvthn_3m                     pvth0=4.2118986e-015+dpvthn_3m
+ k1=0.75128                k2=0.01756084+dk2n_3m     lk2=-1.3430424e-008
+ wk2=-1.3326958e-008       pk2=7.3365851e-015        k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=2
+ dvt1=0.182                dvt2=0.0001               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2
+ minv=-0.3                 voffl=-2.6873e-010        dvtp0=3.6e-007
+ dvtp1=0.001               lpe0=1.8e-008             lpeb=1e-010
+ xj=1.4e-007               ngate=1.0051e+020         ndep=3e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00032453727
+ lcit=7.0331333e-010+dlcitn_3m                       wcit=7.32631e-011
+ pcit=-8.3846687e-017+dpcitn_3m                      voff=-0.1289464
+ lvoff=-5.3026488e-009     wvoff=-1.9570797e-009     pvoff=2.5601188e-015
+ nfactor=1.1919075         lnfactor=-2.1963047e-007  wnfactor=-4.8842066e-008
+ pnfactor=5.5897791e-014   eta0=0.015450968          weta0=-9.4192723e-010
+ etab=-0.044               u0=0.042122905+du0n_3m    lu0=1.3788881e-009
+ wu0=7.4735197e-011        pu0=8.3846687e-016        ua=7.5152658e-011
+ lua=-3.7971823e-016       wua=-9.4882144e-017       pua=-2.7118814e-023
+ ub=1.4610384e-018         lub=4.0064056e-025        wub=1.3771085e-025
+ pub=-8.3623096e-032       uc=8.4288849e-011         luc=1.5263285e-017
+ wuc=-4.7883287e-018       puc=-5.2186178e-024       vsat=70000+dvsatn_3m
+ a0=0.48552029             la0=-2.4428308e-007       wa0=5.2854115e-009
+ pa0=2.9799113e-014        ags=-0.4279937            lags=9.3532967e-007
+ wags=-2.6010287e-007      pags=4.5444904e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.19044576          lketa=1.3232463e-007      wketa=6.7222264e-008
+ pketa=-8.3968824e-014     dwg=0                     dwb=0
+ pclm=0.29921748           lpclm=-1.5410314e-009     wpclm=-6.229817e-008
+ ppclm=5.5897791e-014      pdiblc1=0                 pdiblc2=0.00026823454
+ lpdiblc2=-4.3403484e-011  wpdiblc2=1.7189086e-010   ppdiblc2=-6.428246e-017
+ pdiblcb=0                 drout=0.56                pvag=0.36
+ delta=0.01                pscbe1=5e+008             pscbe2=1e-010
+ fprout=100                pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.3875                rsw=280
+ rdw=280                   rdwmin=1e-006             rswmin=1e-006
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.06e-6            alpha1=8.868              beta0=21.1
+ agidl=1.53e-009           bgidl=2.1917e+009         cgidl=20
+ egidl=0.9035              aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_3m              cgdo=cgon_3m
+ cgbo=0                    cgdl=cgln_3m              cgsl=cgln_3m
+ clc=1e-007                cle=0.6                   cf=cfn_3m
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=5.5934               noff=1.631                voffcv=-0.052318
+ kt1=-0.26512729           lkt1=-6.5753103e-008      wkt1=4.6400347e-009
+ pkt1=9.1225196e-015       kt1l=0                    kt2=-0.039461671
+ lkt2=-1.1722527e-008      wkt2=-6.1875788e-009      pkt2=4.1554418e-015
+ ute=-1.6814475            lute=1.6276628e-007       wute=4.8132424e-008
+ pute=-1.7663702e-014      ua1=3.1733147e-009        lua1=-1.8018757e-016
+ wua1=-3.8295835e-016      pua1=1.4555785e-022       ub1=-5.5952994e-018
+ lub1=1.1858661e-024       wub1=5.1465476e-025       pub1=-1.468994e-031
+ uc1=-1.0158535e-010       luc1=-3.2060153e-019      wuc1=-3.0502699e-018
+ puc1=8.8039021e-024       prt=0                     at=54331.23
+ lat=-0.029396073          wat=-0.0027032634         pat=4.8709335e-009
+ tnoimod=0                 jss=3.93e-07              jsd=3.93e-07
+ jsws=1.43e-12             jswd=1.43e-12             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.04                 bvd=11.04
+ xjbvs=1                   xjbvd=1                   pbs=0.707
+ pbd=0.707                 cjs=cjn_3m                cjd=cjn_3m
+ mjs=0.325                 mjd=0.325                 pbsws=0.630
+ pbswd=0.630               cjsws=cjswn_3m            cjswd=cjswn_3m
+ mjsws=0.204               mjswd=0.204               pbswgs=0.707
+ pbswgd=0.707              cjswgs=cjswgn_3m          cjswgd=cjswgn_3m
+ mjswgs=0.410              mjswgd=0.410              tpb=0.0017
+ tcj=0.00092               tpbsw=0.00175             tcjsw=0.000769
+ tpbswg=0.00146            tcjswg=0.0011             xtis=3
+ xtid=3                    jtsswgs=1e-010            jtsswgd=1e-010
+ njtsswg=45                dmcg=2.05e-7              dmci=3.15e-7
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.35                wlod=3.00e-07             tku0=0.03
+ ku0=-5.50e-08             llodku0=1                 wlodku0=1
+ lku0=1.49e-07             wku0=5.00e-06             pku0=0.00e+00
+ kvth0=3.20e-10            stk2=0.00e+00             steta0=-1.10e-10
+ lkvth0=-1.80e-07          wkvth0=2.00e-06           pkvth0=0.00e+00
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 wec=0                     web=0
+ scref=1.00e-06            wpemod=1                  kvth0we=4.50e-03
+ pkvth0we=-9.00e-17        wkvth0we=1.00e-10         lkvth0we=9.30e-10
+ ku0we=0                   pku0we=0                  wku0we=0
+ lku0we=0                  k2we=4.60e-03             lk2we=8.50e-10
+ wk2we=-1.50e-10           xgl=0                     pvsat=0+dpvsatn_3m
+ fnoimod=1                 noia=noian_3m             noib=noibn_3m
+ noic=noicn_3m             em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
     } 
endsection mos_3m
 
// **************************************************************

section mos_na
// *********************************************************************************************
//                                                                            
//                   *
//                              1.8V CORE NATIVE NMOS DEVICE MODELS           
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt nanch_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 xw= + 0 
+ + dxwn_na ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg 
+ + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + 
+ (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) 
+ * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_na 
+ temp1=parn1_na temp2=parn2_na fac1=0.089793 * temp1 * sigma + 0.995960 * temp2 
+ * sigma fac2=0.089793 * temp1 * sigma - 0.995960 * temp2 * sigma lef=l * factor 
+ - 1.5e-08 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisn_na=0.00372278 * geo_fac * fac1 * mismatchflag dlmisn_na=0.00357013 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisn_na= - 0.00357013 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisn_na=0.00357013 * geo_fac * toxn_na * fac2 * mismatchflag 
nanch_mac ( n1 n2 n3 n4 ) nanch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nanch bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.033+(dvth0n_na+vthmisn_na)                  k1=0.042
+ k2=0.0030793+dk2n_na      k3=-2.2                   k3b=0
+ w0=0                      dvt0=9.8                  dvt1=1.336
+ dvt2=0.09984              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.55                 minv=0
+ voffl=0                   dvtp0=1.532e-005          dvtp1=1
+ lpe0=1.759e-007           lpeb=3.058e-009           xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.075
+ nfactor=1.1               eta0=0.21                 etab=-0.0416
+ u0=0.056+du0n_na          ua=9.221e-010             ub=1.992e-018
+ uc=-2.5346e-011           vsat=234100               a0=4.116
+ ags=1.8                   a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.02348
+ dwg=0                     dwb=0                     pclm=0.7724
+ pdiblc1=0                 pdiblc2=0.03803           pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.3217               kt1l=0
+ kt2=-0.01486              ute=-2.307                ua1=-4.466e-010
+ ub1=-3.1251e-018          uc1=-4e-011               prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        wvth0=0+dwvth0n_na
+ lu0=0+dlu0n_na            pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ lvoff=0+dlvoffn_na        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     2: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.030245482+(dvth0n_na+vthmisn_na)            lvth0=-2.7452639e-008+dlvth0n_na
+ k1=0.042                  k2=0.0035260828+dk2n_na   lk2=-4.4528181e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.083390686         lvoff=8.3624963e-008+dlvoffn_na
+ nfactor=1.1423772         lnfactor=-4.223483e-007   eta0=0.21
+ etab=-0.0416              u0=0.055576228+du0n_na    lu0=4.223483e-009+dlu0n_na
+ ua=1.0819044e-009         lua=-1.5926754e-015       ub=1.6580677e-018
+ lub=3.3281046e-024        uc=-2.0817996e-011        luc=-4.5127915e-017
+ vsat=234100               a0=4.116                  ags=1.8050853
+ lags=-5.0681796e-008      a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.020717007
+ lketa=-2.7537109e-008     dwg=0                     dwb=0
+ pclm=0.67594949           lpclm=9.6126472e-007      pdiblc1=0
+ pdiblc2=0.041432889       lpdiblc2=-3.3914568e-008  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.29665508           lkt1=-2.4960784e-007
+ kt1l=0                    kt2=-0.01486              ute=-2.5294803
+ lute=2.2173286e-006       ua1=-1.104167e-009        lua1=6.5535785e-015
+ ub1=-3.5370064e-018       lub1=4.1052254e-024       uc1=-4.3559685e-011
+ luc1=3.5477257e-017       prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.039824001+(dvth0n_na+vthmisn_na)            lvth0=9.6111819e-010+dlvth0n_na
+ k1=0.042                  k2=0.00070488987+dk2n_na  lk2=3.91598e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052089589         lvoff=-9.2267346e-009+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056351998+du0n_na    lu0=1.9222364e-009+dlu0n_na
+ ua=3.1366321e-010         lua=6.8623839e-016        ub=3.1882414e-018
+ lub=-1.2110089e-024       uc=-3.9344883e-011        luc=9.8303169e-018
+ vsat=234100               a0=4.116                  ags=1.7672639
+ lags=6.1511564e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.038119468
+ lketa=2.4085622e-008      dwg=0                     dwb=0
+ pclm=1.1474853            lpclm=-4.37501e-007       pdiblc1=0
+ pdiblc2=0.033240011       lpdiblc2=-9.6111819e-009  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.39013123           lkt1=2.7680204e-008
+ kt1l=0                    kt2=-0.01486              ute=-1.782
+ ua1=1.0740607e-009        lua1=9.2075123e-017       ub1=-1.7962452e-018
+ lub1=-1.0585756e-024      uc1=-3.9116826e-011       luc1=2.2297942e-017
+ prt=0                     at=364800.22              lat=-0.19222364
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     4: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.049327517+(dvth0n_na+vthmisn_na)            lvth0=1.2046057e-008+dlvth0n_na
+ k1=0.042                  k2=0.0048179744+dk2n_na   lk2=-8.8153825e-010
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037346091         lvoff=-2.642361e-008+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056840653+du0n_na    lu0=1.3522671e-009+dlu0n_na
+ ua=9.2378773e-010         lua=-2.5413295e-017       ub=1.8634947e-018
+ lub=3.3418095e-025        uc=-1.6488459e-011        luc=-1.6829508e-017
+ vsat=234100               a0=4.116                  ags=1.7467079
+ lags=8.5488149e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.023869196
+ lketa=7.464048e-009       dwg=0                     dwb=0
+ pclm=0.75401036           lpclm=2.1449754e-008      pdiblc1=0
+ pdiblc2=0.0016798         lpdiblc2=2.7200775e-008   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.38725492           lkt1=2.4325264e-008
+ kt1l=0                    kt2=-0.01486              ute=-1.9818874
+ lute=2.331495e-007        ua1=9.4795953e-011        lua1=1.2342934e-015
+ ub1=-1.5070073e-018       lub1=-1.3959438e-024      uc1=-3.16601e-011
+ luc1=1.3600387e-017       prt=0                     at=257301.06
+ lat=-0.066836189          jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wvth0=0+dwvth0n_na        pu0=0+dpu0n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wk2=0+dwk2n_na            pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035258546+(dvth0n_na+vthmisn_na)            wvth0=2.2680765e-008+dwvth0n_na
+ k1=0.042                  k2=0.003231653+dk2n_na    wk2=-1.5299594e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.075705796         wvoff=7.0877391e-009
+ nfactor=1.1141159         wnfactor=-1.4175478e-007  eta0=0.21
+ etab=-0.0416              u0=0.056282318+du0n_na    wu0=-2.8350957e-009
+ ua=8.8033103e-010         wua=4.194524e-016         ub=2.1204548e-018
+ wub=-1.2899685e-024       uc=-1.7209025e-011        wuc=-8.1713127e-017
+ vsat=234100               a0=4.116                  ags=1.8230089
+ wags=-2.310603e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.019582598
+ wketa=-3.9138495e-008     dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.037751917
+ wpdiblc2=2.7925692e-009   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.3217               kt1l=0                    kt2=-0.01486
+ ute=-2.3811085            wute=7.4421261e-007       ua1=-6.6236167e-010
+ wua1=2.1667219e-015       ub1=-3.1782464e-018       wub1=5.3370676e-025
+ uc1=-4.3077268e-011       wuc1=3.0902543e-017       prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            lvoff=0+dlvoffn_na        saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     6: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.031756287+(dvth0n_na+vthmisn_na)            lvth0=-3.4904927e-008+dlvth0n_na
+ wvth0=1.5171802e-008+dwvth0n_na                     pvth0=7.4837363e-014
+ k1=0.042                  k2=0.0037415033+dk2n_na   lk2=-5.0813738e-009
+ wk2=-2.1632954e-009+dwk2n_na                        pk2=6.3120826e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084981806         lvoff=9.2448471e-008+dlvoffn_na
+ wvoff=1.5978352e-008      pvoff=-8.8607438e-014+dpvoffn_na
+ nfactor=1.162475          lnfactor=-4.819666e-007   wnfactor=-2.0182649e-007
+ pnfactor=5.9869891e-013   eta0=0.21                 etab=-0.0416
+ u0=0.055978185+du0n_na    lu0=3.0311169e-009+dlu0n_na
+ wu0=-4.0365298e-009       pu0=1.1973978e-014+dpu0n_na
+ ua=1.0449928e-009         lua=-1.6410855e-015       wua=3.7067417e-016
+ pua=4.8614351e-022        ub=1.7962132e-018         lub=3.2315229e-024
+ wub=-1.3872847e-024       pub=9.6989223e-031        uc=-1.0698671e-011
+ luc=-6.4884824e-017       wuc=-1.0162029e-016       puc=1.9840283e-022
+ vsat=234100               a0=4.116                  ags=1.8331788
+ lags=-1.0135735e-007      wags=-2.8212125e-007      pags=5.0889407e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.014766607         lketa=-4.799811e-008
+ wketa=-5.9755105e-008     pketa=2.0547347e-013      dwg=0
+ dwb=0                     pclm=0.66233463           lpclm=1.096956e-006
+ wpclm=1.3672321e-007      ppclm=-1.3626387e-012     pdiblc1=0
+ pdiblc2=0.041699759       lpdiblc2=-3.9345795e-008  wpdiblc2=-2.6799634e-009
+ ppdiblc2=5.454147e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.29579368           lkt1=-2.5819288e-007      wkt1=-8.6503259e-009
+ pkt1=8.6212643e-014       kt1l=0                    kt2=-0.01486
+ ute=-2.6433686            lute=2.6137903e-006       wute=1.1436895e-006
+ pute=-3.9813477e-012      ua1=-1.4456269e-009       lua1=7.8063379e-015
+ wua1=3.4290086e-015       pua1=-1.258046e-020       ub1=-3.6321878e-018
+ lub1=4.5241632e-024       wub1=9.5583065e-025       pub1=-4.2070572e-030
+ uc1=-4.8443495e-011       luc1=5.3481984e-017       wuc1=4.9044198e-017
+ puc1=-1.8080707e-022      prt=0                     at=297009.04
+ lat=0.029809151           wat=0.030035854           pat=-2.9934945e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.042703643+(dvth0n_na+vthmisn_na)            lvth0=-2.4306461e-009+dlvth0n_na
+ wvth0=2.8917936e-008+dwvth0n_na                     pvth0=3.4060775e-014
+ k1=0.042                  k2=0.0005284763+dk2n_na   lk2=4.4497623e-009
+ wk2=1.7715804e-009+dwk2n_na                         pk2=-5.3603485e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.051599906         lvoff=-6.5757317e-009+dlvoffn_na
+ wvoff=-4.9174993e-009     pvoff=-2.6621902e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056260526+du0n_na    lu0=2.1935775e-009+dlu0n_na
+ wu0=9.1857414e-010        pu0=-2.724862e-015+dpu0n_na
+ ua=2.2557236e-010         lua=7.896465e-016         wua=8.8462589e-016
+ pua=-1.0384449e-021       ub=3.3417594e-018         lub=-1.3531917e-024
+ wub=-1.5416586e-024       pub=1.4278277e-030        uc=-3.6841016e-011
+ luc=1.2663932e-017        wuc=-2.514434e-017        puc=-2.8455734e-023
+ vsat=234100               a0=4.116                  ags=1.8073622
+ lags=-2.4774918e-008      wags=-4.0267531e-007      pags=8.6650612e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.039853025         lketa=2.6418342e-008
+ wketa=1.7408728e-008      pketa=-2.3425639e-014     dwg=0
+ dwb=0                     pclm=1.200432             lpclm=-4.9925825e-007
+ wpclm=-5.3170136e-007     ppclm=6.2017859e-013      pdiblc1=0
+ pdiblc2=0.031074087       lpdiblc2=-7.8257572e-009  wpdiblc2=2.1750648e-008
+ ppdiblc2=-1.7929592e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.3910992            lkt1=2.4521793e-008       wkt1=9.7204857e-009
+ pkt1=3.1717394e-014       kt1l=0                    kt2=-0.01486
+ ute=-1.7494317            lute=-3.798776e-008       wute=-3.2705708e-007
+ pute=3.8148068e-013       ua1=1.1554014e-009        lua1=9.0637015e-017
+ wua1=-8.1683984e-016      pua1=1.4441769e-023       ub1=-1.6695853e-018
+ lub1=-1.2977085e-024      wub1=-1.2719435e-024      pub1=2.4014209e-030
+ uc1=-3.8992158e-011       luc1=2.5445499e-017       wuc1=-1.2519417e-018
+ puc1=-3.1608399e-023      prt=0                     at=376431.75
+ lat=-0.2057907            wat=-0.1168061            pat=1.362431e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.057372314+(dvth0n_na+vthmisn_na)            lvth0=1.4678951e-008+dlvth0n_na
+ wvth0=8.078746e-008+dwvth0n_na                      pvth0=-2.6440045e-014
+ k1=0.042                  k2=0.0054445827+dk2n_na   lk2=-1.2844039e-009
+ wk2=-6.292526e-009+dwk2n_na                         pk2=4.0456574e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.03095598          lvoff=-3.0654889e-008+dlvoffn_na
+ wvoff=-6.4170775e-008     pvoff=4.2491355e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05681816+du0n_na     lu0=1.5431519e-009+dlu0n_na
+ wu0=2.2588211e-010        pu0=-1.9169033e-015+dpu0n_na
+ ua=9.5752489e-010         lua=-6.4105862e-017       wua=-3.3879533e-016
+ pua=3.8855849e-022        ub=1.8146049e-018         lub=4.2808749e-025
+ wub=4.9096126e-025        pub=-9.4302827e-031       uc=-6.0916871e-012
+ luc=-2.3202208e-017       wuc=-1.0440646e-016       puc=6.3995925e-023
+ vsat=234833.61            lvsat=-0.00085569044      wvsat=-0.0073670997
+ pvsat=8.5930146e-009      a0=3.8229306              la0=3.4183736e-007
+ wa0=2.9430619e-006        pa0=-3.4327992e-012       ags=2.1200797
+ lags=-3.8952975e-007      wags=-3.7494734e-006      pags=4.7702248e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.024893915         lketa=8.9699754e-009
+ wketa=1.0290427e-008      pketa=-1.5122824e-014     dwg=0
+ dwb=0                     pclm=0.75141449           lpclm=2.4477581e-008
+ wpclm=2.6068199e-008      ppclm=-3.0406052e-014     pdiblc1=0
+ pdiblc2=-0.0012597167     lpdiblc2=2.988852e-008    wpdiblc2=2.9519214e-008
+ ppdiblc2=-2.6990879e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.39632371           lkt1=3.0615686e-008       wkt1=9.1070573e-008
+ pkt1=-6.3169674e-014      kt1l=0                    kt2=-0.01486
+ ute=-2.0101034            lute=2.6606067e-007       wute=2.8334999e-007
+ pute=-3.3050056e-013      ua1=8.3606401e-011        lua1=1.340783e-015
+ wua1=1.1236773e-016       pua1=-1.0693897e-021      ub1=-1.5227348e-018
+ lub1=-1.4689956e-024      wub1=1.5793827e-025       pub1=7.3360108e-031
+ uc1=-2.8677028e-011       luc1=1.3413891e-017       wuc1=-2.9956606e-017
+ puc1=1.8728365e-024       prt=0                     at=258805.91
+ lat=-0.068591451          wat=-0.015111999          pat=1.7626697e-008
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.020563029+(dvth0n_na+vthmisn_na)            wvth0=4.4259941e-009+dwvth0n_na
+ k1=0.042                  k2=-0.0045025271+dk2n_na  wk2=8.0774392e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.065817314         wvoff=-5.1957322e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052450857+du0n_na    wu0=1.9243453e-009        ua=1.2567286e-009
+ wua=-4.8108631e-017       ub=8.5892343e-019         wub=2.7710572e-025
+ uc=-7.3290042e-011        wuc=-1.2049288e-017       vsat=234100
+ a0=4.116                  ags=1.9584471             wags=-3.9930164e-007
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.062003711         wketa=1.3557012e-008
+ dwg=0                     dwb=0                     pclm=0.7724
+ pdiblc1=0                 pdiblc2=0.068282934       wpdiblc2=-3.513306e-008
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.29954726
+ wkt1=-2.7518137e-008      kt1l=0                    kt2=-0.0079508229
+ wkt2=-8.5825799e-009      ute=-1.782                ua1=1.6331238e-009
+ wua1=-6.8473015e-016      ub1=-3.4752255e-018       wub1=9.0261414e-025
+ uc1=-1.3143429e-012       wuc1=-2.0975363e-017      prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lvoff=0+dlvoffn_na        pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     10: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.015851519+(dvth0n_na+vthmisn_na)            lvth0=-4.6956804e-008+dlvth0n_na
+ wvth0=-4.5851001e-009+dwvth0n_na                    pvth0=8.9808205e-014
+ k1=0.042                  k2=-0.0036802817+dk2n_na  lk2=-8.19483e-009
+ wk2=7.056046e-009+dwk2n_na                          pk2=1.0179618e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.071619046         lvoff=5.7822402e-008+dlvoffn_na
+ wvoff=-6.2086898e-010     pvoff=-4.5594935e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.0508513+du0n_na      lu0=1.5941838e-008+dlu0n_na
+ wu0=2.3320871e-009        pu0=-4.0637197e-015+dpu0n_na
+ ua=1.2914952e-009         lua=-3.4649804e-016       wua=6.4468885e-017
+ pua=-1.121993e-021        ub=5.4923243e-019         lub=3.0865057e-024
+ wub=1.6171478e-025        pub=1.1500327e-030        uc=-8.3609611e-011
+ luc=1.0284899e-016        wuc=-1.105032e-017        puc=-9.9561133e-024
+ vsat=234100               a0=4.116                  ags=1.9340766
+ lags=2.4288647e-007       wags=-4.0745648e-007      pags=8.1274394e-014
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.086054247         lketa=2.3969736e-007
+ wketa=2.8798402e-008      pketa=-1.5190184e-013     dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071595214       lpdiblc2=-3.3011525e-008  wpdiblc2=-3.9816097e-008
+ ppdiblc2=4.667304e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.27594362           lkt1=-2.3524342e-007      wkt1=-3.3308071e-008
+ pkt1=5.770482e-014        kt1l=0                    kt2=-0.005022907
+ lkt2=-2.9180792e-008      wkt2=-1.2219637e-008      pkt2=3.624838e-014
+ ute=-1.6767181            lute=-1.0492821e-006      wute=-5.7083855e-008
+ pute=5.6892076e-013       ua1=2.1142945e-009        lua1=-4.7955415e-015
+ wua1=-9.9312568e-016      pua1=3.0735944e-021       ub1=-4.1325216e-018
+ lub1=6.5508789e-024       wub1=1.5773453e-024       pub1=-6.7246434e-030
+ uc1=1.5079555e-011        luc1=-1.6338821e-016      wuc1=-2.9864135e-017
+ puc1=8.8589089e-023       prt=0                     at=297719.32
+ lat=0.022730182           wat=0.02915354            pat=-2.9055596e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     11: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.045224711+(dvth0n_na+vthmisn_na)            lvth0=4.0175949e-008+dlvth0n_na
+ wvth0=3.2049607e-008+dwvth0n_na                     pvth0=-1.8865137e-014
+ k1=0.042                  k2=-0.00885727+dk2n_na    lk2=7.1622088e-009
+ wk2=1.3430555e-008+dwk2n_na                         pk2=-8.7297497e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037570625         lvoff=-4.3178971e-008+dlvoffn_na
+ wvoff=-2.2344672e-008     pvoff=1.8846642e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.057731201+du0n_na    lu0=-4.4667282e-009+dlu0n_na
+ wu0=-9.0829738e-010       pu0=5.5485697e-015+dpu0n_na
+ ua=1.3986533e-009         lua=-6.6437218e-016       wua=-5.7257519e-016
+ pua=7.677371e-022         ub=1.5171163e-018         lub=2.1537093e-025
+ wub=7.2491301e-025        pub=-5.2064079e-031       uc=-4.8176957e-011
+ luc=-2.2585767e-018       wuc=-1.1062834e-017       puc=-9.9189931e-024
+ vsat=234100               a0=2.8029668              la0=3.8949869e-006
+ wa0=1.6310498e-006        pa0=-4.8383528e-012       ags=2.8507242
+ lags=-2.4762606e-006      wags=-1.6987395e-006      pags=3.9117416e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.000442124         lketa=-1.4262789e-008
+ wketa=-3.1547494e-008     pketa=2.7108462e-014      dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071168372       lpdiblc2=-3.1745339e-008  wpdiblc2=-2.8054474e-008
+ ppdiblc2=1.1783313e-014   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.37796255           lkt1=6.7385941e-008       wkt1=-6.5978622e-009
+ pkt1=-2.152845e-014       kt1l=0                    kt2=-0.01486
+ ute=-2.1914297            lute=4.7756041e-007       wute=2.2199277e-007
+ pute=-2.5893325e-013      ua1=6.4646543e-010        lua1=-4.4136762e-016
+ wua1=-1.8463955e-016      pua1=6.7529792e-022       ub1=-2.2235205e-018
+ lub1=8.8801038e-025       wub1=-5.8384522e-025      pub1=-3.1367914e-031
+ uc1=-3.5382299e-011       luc1=-1.3697966e-017      wuc1=-5.736108e-018
+ puc1=1.7015614e-023       prt=0                     at=373669.54
+ lat=-0.20256884           wat=-0.11337488           pat=1.3224091e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     12: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.0021752367+(dvth0n_na+vthmisn_na)           lvth0=-1.003713e-008+dlvth0n_na
+ wvth0=1.222165e-008+dwvth0n_na                      pvth0=4.2622712e-015
+ k1=0.042                  k2=-0.0067757214+dk2n_na  lk2=4.7342822e-009
+ wk2=8.8875357e-009+dwk2n_na                         pk2=-3.4307544e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.076380358         lvoff=2.0888574e-009+dlvoffn_na
+ wvoff=-7.7446123e-009     pvoff=1.8170735e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.053901714+du0n_na    wu0=3.8486905e-009        ua=6.8485116e-010
+ lua=1.6820943e-016        wua=-8.0018125e-020       pua=9.9976432e-023
+ ub=1.8103891e-018         lub=-1.2670354e-025       wub=4.9619814e-025
+ pub=-2.5386686e-031       uc=-6.3310217e-011        luc=1.5392919e-017
+ wuc=-3.3329606e-017       puc=1.6053059e-023        vsat=230760.85
+ lvsat=0.0038947956        wvsat=-0.0023079146       pvsat=2.6919608e-009
+ a0=9.5685352              la0=-3.9963991e-006       wa0=-4.1941282e-006
+ pa0=1.9561582e-012        ags=-1.8796554            lags=3.0412731e-006
+ wags=1.2189975e-006       pags=5.0848148e-013       a1=0
+ a2=0.2021                 b0=0                      b1=0
+ keta=-0.0043770989        lketa=-9.6730187e-009     wketa=-1.5195561e-008
+ pketa=8.0355029e-015      dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.038843752
+ lpdiblc2=5.9582269e-009   wpdiblc2=-2.0297315e-008  ppdiblc2=2.7353312e-015
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.29683264
+ lkt1=-2.7244305e-008      wkt1=-3.2517232e-008      pkt1=8.7040065e-015
+ kt1l=0                    kt2=-0.01486              ute=-1.782
+ ua1=-3.3613987e-010       lua1=7.0474714e-016       wua1=6.3377654e-016
+ pua1=-2.7930589e-022      ub1=-3.4096093e-019       lub1=-1.3078146e-024
+ wub1=-1.3100612e-024      pub1=5.3338212e-031       uc1=-7.4575817e-011
+ luc1=3.201751e-017        wuc1=2.705887e-017        puc1=-2.1236579e-023
+ prt=0                     at=246640.4               lat=-0.054401549
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lu0=0+dlu0n_na            saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pu0=0+dpu0n_na            fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.019665613+(dvth0n_na+vthmisn_na)            wvth0=3.9394153e-009+dwvth0n_na
+ k1=0.042                  k2=0.0065262484+dk2n_na   wk2=2.0976371e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.061093484         wvoff=-7.7569931e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.050007742+du0n_na    wu0=3.2490023e-009        ua=1.4384007e-009
+ wua=-1.4661123e-016       ub=1.0413548e-019         wub=6.8635174e-025
+ uc=-6.3913576e-011        wuc=-1.7133208e-017       vsat=234100
+ a0=5.7009523              wa0=-8.5936111e-007       ags=0.78905936
+ wags=2.3474042e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.047126916
+ wketa=5.4908139e-009      dwg=0                     dwb=0
+ pclm=0.75172671           wpclm=1.1209058e-008      pdiblc1=0
+ pdiblc2=-0.0093686673     wpdiblc2=6.9696379e-009   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.32745452           wkt1=-1.2386821e-008
+ kt1l=0                    kt2=-0.021113445          wkt2=-1.445806e-009
+ ute=-1.782                ua1=2.1538758e-010        wua1=8.3966404e-017
+ ub1=-1.1078328e-018       wub1=-3.8098614e-025      uc1=-9.0507994e-011
+ wuc1=2.7385435e-017       prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvth0n_na        lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ lvoff=0+dlvoffn_na        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     14: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035827019+(dvth0n_na+vthmisn_na)            lvth0=1.6107111e-007+dlvth0n_na
+ wvth0=6.245616e-009+dwvth0n_na                      pvth0=-2.2984527e-014
+ k1=0.042                  k2=0.0030951675+dk2n_na   lk2=3.4195539e-008
+ wk2=3.3823974e-009+dwk2n_na                         pk2=-1.280444e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052420315         lvoff=-8.6440309e-008+dlvoffn_na
+ wvoff=-1.1030421e-008     pvoff=3.2624307e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05138213+du0n_na     lu0=-1.3697709e-008+dlu0n_na
+ wu0=2.0442706e-009        pu0=1.2006843e-014+dpu0n_na
+ ua=2.0784924e-009         lua=-6.3794127e-015       wua=-3.6224099e-016
+ pua=2.1490533e-021        ub=-9.747155e-019         lub=1.0752265e-023
+ wub=9.8799934e-025        pub=-3.0063419e-030       uc=-7.7461161e-011
+ luc=1.350207e-016         wuc=-1.438401e-017        puc=-2.7399615e-023
+ vsat=232735.1             lvsat=0.013603157         wvsat=0.00074004946
+ pvsat=-7.3756319e-009     a0=5.5422428              la0=1.5817625e-006
+ wa0=-7.7330885e-007       pa0=-8.5763162e-013       ags=1.0058056
+ lags=-2.1601807e-006      wags=9.5852065e-008       pags=1.3842174e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.040026307         lketa=-7.0767536e-008
+ wketa=3.8420526e-009      pketa=1.6432222e-014      dwg=0
+ dwb=0                     pclm=0.74296595           lpclm=8.7313289e-008
+ wpclm=1.5959143e-008      ppclm=-4.7341266e-014     pdiblc1=0
+ pdiblc2=-0.019522161      lpdiblc2=1.0119382e-007   wpdiblc2=9.5877436e-009
+ ppdiblc2=-2.6093099e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.2890693            lkt1=-3.8256257e-007      wkt1=-2.6191325e-008
+ pkt1=1.3758127e-013       kt1l=0                    kt2=-0.02376348
+ lkt2=2.6411319e-008       wkt2=-2.0584982e-009      pkt2=6.1063371e-015
+ ute=-1.782                ua1=-1.4873088e-010       lua1=3.6289517e-015
+ wua1=2.3388666e-016       pua1=-1.4941658e-021      ub1=3.102742e-019
+ lub1=-1.4133428e-023      wub1=-8.3153858e-025      pub1=4.4903876e-030
+ uc1=-9.9215112e-011       luc1=8.6778654e-017       wuc1=3.2106434e-017
+ puc1=-4.7051386e-023      prt=0                     at=374183.75
+ lat=-0.73934522           wat=-0.012305474          pat=1.2264132e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     15: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.023161032+(dvth0n_na+vthmisn_na)             lvth0=-1.3911287e-008+dlvth0n_na
+ wvth0=-5.0291428e-009+dwvth0n_na                    pvth0=1.0460962e-014
+ k1=0.042                  k2=0.017369029+dk2n_na    lk2=-8.1464998e-009
+ wk2=-7.8934462e-010+dwk2n_na                        pk2=-4.2936785e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084779302         lvoff=9.5495215e-009+dlvoffn_na
+ wvoff=3.2518727e-009      pvoff=-9.7427467e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.042879011+du0n_na    lu0=1.1525977e-008+dlu0n_na
+ wu0=7.1445597e-009        pu0=-3.1226752e-015+dpu0n_na
+ ua=-8.5560538e-010        lua=2.3243066e-015        wua=6.4968384e-016
+ pua=-8.5272454e-022       ub=3.4651675e-018         lub=-2.418222e-024
+ wub=-3.3132034e-025       pub=9.0729329e-031        uc=-6.0078563e-012
+ luc=-7.6938667e-017       wuc=-3.392692e-017        puc=3.0572552e-023
+ vsat=239407.95            lvsat=-0.0061912134       wvsat=-0.0028779701
+ pvsat=3.3568759e-009      a0=9.0403821              la0=-8.7951318e-006
+ wa0=-1.7508767e-006       pa0=2.0422296e-012        ags=-1.5260194
+ lags=5.3502349e-006       wags=6.7433082e-007       pags=-3.3178424e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.091514384         lketa=8.19669e-008
+ wketa=1.7831886e-008      pketa=-2.5067276e-014     dwg=0
+ dwb=0                     pclm=0.8343338            lpclm=-1.8372066e-007
+ wpclm=-3.3580504e-008     ppclm=9.961334e-014       pdiblc1=0
+ pdiblc2=0.018553398       lpdiblc2=-1.1753668e-008  wpdiblc2=4.7336555e-010
+ ppdiblc2=9.4382859e-016   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.47930556           lkt1=1.8175503e-007       wkt1=4.835032e-008
+ pkt1=-8.3539369e-014      kt1l=0                    kt2=-0.01486
+ ute=-1.782                ua1=9.22964e-010          lua1=4.4987173e-016
+ wua1=-3.3455707e-016      pua1=1.9206795e-022       ub1=-4.9246222e-018
+ lub1=1.3953901e-024       wub1=8.8069215e-025       pub1=-5.8878042e-031
+ uc1=-9.980334e-011        luc1=8.8523574e-017       wuc1=2.919298e-017
+ puc1=-3.8408905e-023      prt=0                     at=65872.311
+ lat=0.17523107            wat=0.053512777           pat=-7.2602199e-008
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     16: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.020835647+(dvth0n_na+vthmisn_na)             lvth0=-1.1198948e-008+dlvth0n_na
+ wvth0=-2.5485058e-010+dwvth0n_na                    pvth0=4.8922085e-015
+ k1=0.042                  k2=0.011276519+dk2n_na    lk2=-1.0401727e-009
+ wk2=-9.0038917e-010+dwk2n_na                        pk2=-2.9984504e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.094701242         lvoff=2.1122512e-008+dlvoffn_na
+ wvoff=2.1889711e-009      pvoff=-8.502974e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052760645+du0n_na    wu0=4.4673782e-009        ua=1.0203154e-009
+ lua=1.3622514e-016        wua=-1.8196871e-016       pua=1.1731832e-022
+ ub=1.3457674e-018         lub=5.3854776e-026        wub=7.4811601e-025
+ pub=-3.5176557e-031       uc=-1.1618645e-010        luc=5.1574084e-017
+ wuc=-4.6601134e-018       puc=-3.5643684e-024       vsat=247565.19
+ lvsat=-0.015705853        wvsat=-0.011419227        pvsat=1.3319432e-008
+ a0=1.8331457              la0=-3.8858249e-007       ags=-2.7302665
+ lags=6.7548736e-006       wags=1.6801988e-006       pags=-1.5050327e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.010493704         lketa=-1.2535946e-008
+ wketa=-1.1879138e-008     pketa=9.5877818e-015      dwg=0
+ dwb=0                     pclm=0.67682348           wpclm=5.1821587e-008
+ pdiblc1=0                 pdiblc2=0.0074486026      lpdiblc2=1.1990091e-009
+ wpdiblc2=-3.2748645e-009  ppdiblc2=5.3157791e-015   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.29242568           lkt1=-3.6222407e-008
+ wkt1=-3.4906685e-008      pkt1=1.3571933e-014       kt1l=0
+ kt2=-0.01486              ute=-1.782                ua1=8.1267718e-010
+ lua1=5.7851072e-016       wua1=1.0887941e-017       pua1=-2.108605e-022
+ ub1=-2.9685052e-018       lub1=-8.8623267e-025      wub1=1.1459327e-025
+ pub1=3.0480037e-031       uc1=-1.3187543e-011       luc1=-1.2505437e-017
+ wuc1=-6.2258524e-018      puc1=2.9037625e-024       prt=0
+ at=278465.42              lat=-0.072738381          wat=-0.017255524
+ pat=9.9422302e-009        jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
     } 
ends nanch_mac
// 
 
// *********************************************************************************************
//                                                                            
//                   *
//                              1.8V CORE NATIVE NMOS DEVICE MODELS           
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
model nanch bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.033+dvth0n_na     k1=0.042                  k2=0.0030793+dk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.075               nfactor=1.1
+ eta0=0.21                 etab=-0.0416              u0=0.056+du0n_na
+ ua=9.221e-010             ub=1.992e-018             uc=-2.5346e-011
+ vsat=234100               a0=4.116                  ags=1.8
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.02348             dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.03803           pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.3217               kt1l=0                    kt2=-0.01486
+ ute=-2.307                ua1=-4.466e-010           ub1=-3.1251e-018
+ uc1=-4e-011               prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvth0n_na        wvth0=0+dwvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            wk2=0+dwk2n_na            lvoff=0+dlvoffn_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     2: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.030245482+dvth0n_na                         lvth0=-2.7452639e-008+dlvth0n_na
+ k1=0.042                  k2=0.0035260828+dk2n_na   lk2=-4.4528181e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.083390686         lvoff=8.3624963e-008+dlvoffn_na
+ nfactor=1.1423772         lnfactor=-4.223483e-007   eta0=0.21
+ etab=-0.0416              u0=0.055576228+du0n_na    lu0=4.223483e-009+dlu0n_na
+ ua=1.0819044e-009         lua=-1.5926754e-015       ub=1.6580677e-018
+ lub=3.3281046e-024        uc=-2.0817996e-011        luc=-4.5127915e-017
+ vsat=234100               a0=4.116                  ags=1.8050853
+ lags=-5.0681796e-008      a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.020717007
+ lketa=-2.7537109e-008     dwg=0                     dwb=0
+ pclm=0.67594949           lpclm=9.6126472e-007      pdiblc1=0
+ pdiblc2=0.041432889       lpdiblc2=-3.3914568e-008  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.29665508           lkt1=-2.4960784e-007
+ kt1l=0                    kt2=-0.01486              ute=-2.5294803
+ lute=2.2173286e-006       ua1=-1.104167e-009        lua1=6.5535785e-015
+ ub1=-3.5370064e-018       lub1=4.1052254e-024       uc1=-4.3559685e-011
+ luc1=3.5477257e-017       prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.039824001+dvth0n_na                         lvth0=9.6111819e-010+dlvth0n_na
+ k1=0.042                  k2=0.00070488987+dk2n_na  lk2=3.91598e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052089589         lvoff=-9.2267346e-009+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056351998+du0n_na    lu0=1.9222364e-009+dlu0n_na
+ ua=3.1366321e-010         lua=6.8623839e-016        ub=3.1882414e-018
+ lub=-1.2110089e-024       uc=-3.9344883e-011        luc=9.8303169e-018
+ vsat=234100               a0=4.116                  ags=1.7672639
+ lags=6.1511564e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.038119468
+ lketa=2.4085622e-008      dwg=0                     dwb=0
+ pclm=1.1474853            lpclm=-4.37501e-007       pdiblc1=0
+ pdiblc2=0.033240011       lpdiblc2=-9.6111819e-009  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.39013123           lkt1=2.7680204e-008
+ kt1l=0                    kt2=-0.01486              ute=-1.782
+ ua1=1.0740607e-009        lua1=9.2075123e-017       ub1=-1.7962452e-018
+ lub1=-1.0585756e-024      uc1=-3.9116826e-011       luc1=2.2297942e-017
+ prt=0                     at=364800.22              lat=-0.19222364
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     4: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.049327517+dvth0n_na                         lvth0=1.2046057e-008+dlvth0n_na
+ k1=0.042                  k2=0.0048179744+dk2n_na   lk2=-8.8153825e-010
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037346091         lvoff=-2.642361e-008+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056840653+du0n_na    lu0=1.3522671e-009+dlu0n_na
+ ua=9.2378773e-010         lua=-2.5413295e-017       ub=1.8634947e-018
+ lub=3.3418095e-025        uc=-1.6488459e-011        luc=-1.6829508e-017
+ vsat=234100               a0=4.116                  ags=1.7467079
+ lags=8.5488149e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.023869196
+ lketa=7.464048e-009       dwg=0                     dwb=0
+ pclm=0.75401036           lpclm=2.1449754e-008      pdiblc1=0
+ pdiblc2=0.0016798         lpdiblc2=2.7200775e-008   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.38725492           lkt1=2.4325264e-008
+ kt1l=0                    kt2=-0.01486              ute=-1.9818874
+ lute=2.331495e-007        ua1=9.4795953e-011        lua1=1.2342934e-015
+ ub1=-1.5070073e-018       lub1=-1.3959438e-024      uc1=-3.16601e-011
+ luc1=1.3600387e-017       prt=0                     at=257301.06
+ lat=-0.066836189          jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wvth0=0+dwvth0n_na        pu0=0+dpu0n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ wk2=0+dwk2n_na            pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035258546+dvth0n_na                         wvth0=2.2680765e-008+dwvth0n_na
+ k1=0.042                  k2=0.003231653+dk2n_na    wk2=-1.5299594e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.075705796         wvoff=7.0877391e-009
+ nfactor=1.1141159         wnfactor=-1.4175478e-007  eta0=0.21
+ etab=-0.0416              u0=0.056282318+du0n_na    wu0=-2.8350957e-009
+ ua=8.8033103e-010         wua=4.194524e-016         ub=2.1204548e-018
+ wub=-1.2899685e-024       uc=-1.7209025e-011        wuc=-8.1713127e-017
+ vsat=234100               a0=4.116                  ags=1.8230089
+ wags=-2.310603e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.019582598
+ wketa=-3.9138495e-008     dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.037751917
+ wpdiblc2=2.7925692e-009   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.3217               kt1l=0                    kt2=-0.01486
+ ute=-2.3811085            wute=7.4421261e-007       ua1=-6.6236167e-010
+ wua1=2.1667219e-015       ub1=-3.1782464e-018       wub1=5.3370676e-025
+ uc1=-4.3077268e-011       wuc1=3.0902543e-017       prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            lvoff=0+dlvoffn_na        saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     6: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.031756287+dvth0n_na                         lvth0=-3.4904927e-008+dlvth0n_na
+ wvth0=1.5171802e-008+dwvth0n_na                     pvth0=7.4837363e-014
+ k1=0.042                  k2=0.0037415033+dk2n_na   lk2=-5.0813738e-009
+ wk2=-2.1632954e-009+dwk2n_na                        pk2=6.3120826e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084981806         lvoff=9.2448471e-008+dlvoffn_na
+ wvoff=1.5978352e-008      pvoff=-8.8607438e-014+dpvoffn_na
+ nfactor=1.162475          lnfactor=-4.819666e-007   wnfactor=-2.0182649e-007
+ pnfactor=5.9869891e-013   eta0=0.21                 etab=-0.0416
+ u0=0.055978185+du0n_na    lu0=3.0311169e-009+dlu0n_na
+ wu0=-4.0365298e-009       pu0=1.1973978e-014+dpu0n_na
+ ua=1.0449928e-009         lua=-1.6410855e-015       wua=3.7067417e-016
+ pua=4.8614351e-022        ub=1.7962132e-018         lub=3.2315229e-024
+ wub=-1.3872847e-024       pub=9.6989223e-031        uc=-1.0698671e-011
+ luc=-6.4884824e-017       wuc=-1.0162029e-016       puc=1.9840283e-022
+ vsat=234100               a0=4.116                  ags=1.8331788
+ lags=-1.0135735e-007      wags=-2.8212125e-007      pags=5.0889407e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.014766607         lketa=-4.799811e-008
+ wketa=-5.9755105e-008     pketa=2.0547347e-013      dwg=0
+ dwb=0                     pclm=0.66233463           lpclm=1.096956e-006
+ wpclm=1.3672321e-007      ppclm=-1.3626387e-012     pdiblc1=0
+ pdiblc2=0.041699759       lpdiblc2=-3.9345795e-008  wpdiblc2=-2.6799634e-009
+ ppdiblc2=5.454147e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.29579368           lkt1=-2.5819288e-007      wkt1=-8.6503259e-009
+ pkt1=8.6212643e-014       kt1l=0                    kt2=-0.01486
+ ute=-2.6433686            lute=2.6137903e-006       wute=1.1436895e-006
+ pute=-3.9813477e-012      ua1=-1.4456269e-009       lua1=7.8063379e-015
+ wua1=3.4290086e-015       pua1=-1.258046e-020       ub1=-3.6321878e-018
+ lub1=4.5241632e-024       wub1=9.5583065e-025       pub1=-4.2070572e-030
+ uc1=-4.8443495e-011       luc1=5.3481984e-017       wuc1=4.9044198e-017
+ puc1=-1.8080707e-022      prt=0                     at=297009.04
+ lat=0.029809151           wat=0.030035854           pat=-2.9934945e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.042703643+dvth0n_na                         lvth0=-2.4306461e-009+dlvth0n_na
+ wvth0=2.8917936e-008+dwvth0n_na                     pvth0=3.4060775e-014
+ k1=0.042                  k2=0.0005284763+dk2n_na   lk2=4.4497623e-009
+ wk2=1.7715804e-009+dwk2n_na                         pk2=-5.3603485e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.051599906         lvoff=-6.5757317e-009+dlvoffn_na
+ wvoff=-4.9174993e-009     pvoff=-2.6621902e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056260526+du0n_na    lu0=2.1935775e-009+dlu0n_na
+ wu0=9.1857414e-010        pu0=-2.724862e-015+dpu0n_na
+ ua=2.2557236e-010         lua=7.896465e-016         wua=8.8462589e-016
+ pua=-1.0384449e-021       ub=3.3417594e-018         lub=-1.3531917e-024
+ wub=-1.5416586e-024       pub=1.4278277e-030        uc=-3.6841016e-011
+ luc=1.2663932e-017        wuc=-2.514434e-017        puc=-2.8455734e-023
+ vsat=234100               a0=4.116                  ags=1.8073622
+ lags=-2.4774918e-008      wags=-4.0267531e-007      pags=8.6650612e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.039853025         lketa=2.6418342e-008
+ wketa=1.7408728e-008      pketa=-2.3425639e-014     dwg=0
+ dwb=0                     pclm=1.200432             lpclm=-4.9925825e-007
+ wpclm=-5.3170136e-007     ppclm=6.2017859e-013      pdiblc1=0
+ pdiblc2=0.031074087       lpdiblc2=-7.8257572e-009  wpdiblc2=2.1750648e-008
+ ppdiblc2=-1.7929592e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.3910992            lkt1=2.4521793e-008       wkt1=9.7204857e-009
+ pkt1=3.1717394e-014       kt1l=0                    kt2=-0.01486
+ ute=-1.7494317            lute=-3.798776e-008       wute=-3.2705708e-007
+ pute=3.8148068e-013       ua1=1.1554014e-009        lua1=9.0637015e-017
+ wua1=-8.1683984e-016      pua1=1.4441769e-023       ub1=-1.6695853e-018
+ lub1=-1.2977085e-024      wub1=-1.2719435e-024      pub1=2.4014209e-030
+ uc1=-3.8992158e-011       luc1=2.5445499e-017       wuc1=-1.2519417e-018
+ puc1=-3.1608399e-023      prt=0                     at=376431.75
+ lat=-0.2057907            wat=-0.1168061            pat=1.362431e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.057372314+dvth0n_na                         lvth0=1.4678951e-008+dlvth0n_na
+ wvth0=8.078746e-008+dwvth0n_na                      pvth0=-2.6440045e-014
+ k1=0.042                  k2=0.0054445827+dk2n_na   lk2=-1.2844039e-009
+ wk2=-6.292526e-009+dwk2n_na                         pk2=4.0456574e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.03095598          lvoff=-3.0654889e-008+dlvoffn_na
+ wvoff=-6.4170775e-008     pvoff=4.2491355e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05681816+du0n_na     lu0=1.5431519e-009+dlu0n_na
+ wu0=2.2588211e-010        pu0=-1.9169033e-015+dpu0n_na
+ ua=9.5752489e-010         lua=-6.4105862e-017       wua=-3.3879533e-016
+ pua=3.8855849e-022        ub=1.8146049e-018         lub=4.2808749e-025
+ wub=4.9096126e-025        pub=-9.4302827e-031       uc=-6.0916871e-012
+ luc=-2.3202208e-017       wuc=-1.0440646e-016       puc=6.3995925e-023
+ vsat=234833.61            lvsat=-0.00085569044      wvsat=-0.0073670997
+ pvsat=8.5930146e-009      a0=3.8229306              la0=3.4183736e-007
+ wa0=2.9430619e-006        pa0=-3.4327992e-012       ags=2.1200797
+ lags=-3.8952975e-007      wags=-3.7494734e-006      pags=4.7702248e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.024893915         lketa=8.9699754e-009
+ wketa=1.0290427e-008      pketa=-1.5122824e-014     dwg=0
+ dwb=0                     pclm=0.75141449           lpclm=2.4477581e-008
+ wpclm=2.6068199e-008      ppclm=-3.0406052e-014     pdiblc1=0
+ pdiblc2=-0.0012597167     lpdiblc2=2.988852e-008    wpdiblc2=2.9519214e-008
+ ppdiblc2=-2.6990879e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.39632371           lkt1=3.0615686e-008       wkt1=9.1070573e-008
+ pkt1=-6.3169674e-014      kt1l=0                    kt2=-0.01486
+ ute=-2.0101034            lute=2.6606067e-007       wute=2.8334999e-007
+ pute=-3.3050056e-013      ua1=8.3606401e-011        lua1=1.340783e-015
+ wua1=1.1236773e-016       pua1=-1.0693897e-021      ub1=-1.5227348e-018
+ lub1=-1.4689956e-024      wub1=1.5793827e-025       pub1=7.3360108e-031
+ uc1=-2.8677028e-011       luc1=1.3413891e-017       wuc1=-2.9956606e-017
+ puc1=1.8728365e-024       prt=0                     at=258805.91
+ lat=-0.068591451          wat=-0.015111999          pat=1.7626697e-008
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.020563029+dvth0n_na                         wvth0=4.4259941e-009+dwvth0n_na
+ k1=0.042                  k2=-0.0045025271+dk2n_na  wk2=8.0774392e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.065817314         wvoff=-5.1957322e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052450857+du0n_na    wu0=1.9243453e-009        ua=1.2567286e-009
+ wua=-4.8108631e-017       ub=8.5892343e-019         wub=2.7710572e-025
+ uc=-7.3290042e-011        wuc=-1.2049288e-017       vsat=234100
+ a0=4.116                  ags=1.9584471             wags=-3.9930164e-007
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.062003711         wketa=1.3557012e-008
+ dwg=0                     dwb=0                     pclm=0.7724
+ pdiblc1=0                 pdiblc2=0.068282934       wpdiblc2=-3.513306e-008
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.29954726
+ wkt1=-2.7518137e-008      kt1l=0                    kt2=-0.0079508229
+ wkt2=-8.5825799e-009      ute=-1.782                ua1=1.6331238e-009
+ wua1=-6.8473015e-016      ub1=-3.4752255e-018       wub1=9.0261414e-025
+ uc1=-1.3143429e-012       wuc1=-2.0975363e-017      prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lvoff=0+dlvoffn_na        pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     10: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.015851519+dvth0n_na                         lvth0=-4.6956804e-008+dlvth0n_na
+ wvth0=-4.5851001e-009+dwvth0n_na                    pvth0=8.9808205e-014
+ k1=0.042                  k2=-0.0036802817+dk2n_na  lk2=-8.19483e-009
+ wk2=7.056046e-009+dwk2n_na                          pk2=1.0179618e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.071619046         lvoff=5.7822402e-008+dlvoffn_na
+ wvoff=-6.2086898e-010     pvoff=-4.5594935e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.0508513+du0n_na      lu0=1.5941838e-008+dlu0n_na
+ wu0=2.3320871e-009        pu0=-4.0637197e-015+dpu0n_na
+ ua=1.2914952e-009         lua=-3.4649804e-016       wua=6.4468885e-017
+ pua=-1.121993e-021        ub=5.4923243e-019         lub=3.0865057e-024
+ wub=1.6171478e-025        pub=1.1500327e-030        uc=-8.3609611e-011
+ luc=1.0284899e-016        wuc=-1.105032e-017        puc=-9.9561133e-024
+ vsat=234100               a0=4.116                  ags=1.9340766
+ lags=2.4288647e-007       wags=-4.0745648e-007      pags=8.1274394e-014
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.086054247         lketa=2.3969736e-007
+ wketa=2.8798402e-008      pketa=-1.5190184e-013     dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071595214       lpdiblc2=-3.3011525e-008  wpdiblc2=-3.9816097e-008
+ ppdiblc2=4.667304e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.27594362           lkt1=-2.3524342e-007      wkt1=-3.3308071e-008
+ pkt1=5.770482e-014        kt1l=0                    kt2=-0.005022907
+ lkt2=-2.9180792e-008      wkt2=-1.2219637e-008      pkt2=3.624838e-014
+ ute=-1.6767181            lute=-1.0492821e-006      wute=-5.7083855e-008
+ pute=5.6892076e-013       ua1=2.1142945e-009        lua1=-4.7955415e-015
+ wua1=-9.9312568e-016      pua1=3.0735944e-021       ub1=-4.1325216e-018
+ lub1=6.5508789e-024       wub1=1.5773453e-024       pub1=-6.7246434e-030
+ uc1=1.5079555e-011        luc1=-1.6338821e-016      wuc1=-2.9864135e-017
+ puc1=8.8589089e-023       prt=0                     at=297719.32
+ lat=0.022730182           wat=0.02915354            pat=-2.9055596e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     11: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.045224711+dvth0n_na                         lvth0=4.0175949e-008+dlvth0n_na
+ wvth0=3.2049607e-008+dwvth0n_na                     pvth0=-1.8865137e-014
+ k1=0.042                  k2=-0.00885727+dk2n_na    lk2=7.1622088e-009
+ wk2=1.3430555e-008+dwk2n_na                         pk2=-8.7297497e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037570625         lvoff=-4.3178971e-008+dlvoffn_na
+ wvoff=-2.2344672e-008     pvoff=1.8846642e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.057731201+du0n_na    lu0=-4.4667282e-009+dlu0n_na
+ wu0=-9.0829738e-010       pu0=5.5485697e-015+dpu0n_na
+ ua=1.3986533e-009         lua=-6.6437218e-016       wua=-5.7257519e-016
+ pua=7.677371e-022         ub=1.5171163e-018         lub=2.1537093e-025
+ wub=7.2491301e-025        pub=-5.2064079e-031       uc=-4.8176957e-011
+ luc=-2.2585767e-018       wuc=-1.1062834e-017       puc=-9.9189931e-024
+ vsat=234100               a0=2.8029668              la0=3.8949869e-006
+ wa0=1.6310498e-006        pa0=-4.8383528e-012       ags=2.8507242
+ lags=-2.4762606e-006      wags=-1.6987395e-006      pags=3.9117416e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.000442124         lketa=-1.4262789e-008
+ wketa=-3.1547494e-008     pketa=2.7108462e-014      dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071168372       lpdiblc2=-3.1745339e-008  wpdiblc2=-2.8054474e-008
+ ppdiblc2=1.1783313e-014   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.37796255           lkt1=6.7385941e-008       wkt1=-6.5978622e-009
+ pkt1=-2.152845e-014       kt1l=0                    kt2=-0.01486
+ ute=-2.1914297            lute=4.7756041e-007       wute=2.2199277e-007
+ pute=-2.5893325e-013      ua1=6.4646543e-010        lua1=-4.4136762e-016
+ wua1=-1.8463955e-016      pua1=6.7529792e-022       ub1=-2.2235205e-018
+ lub1=8.8801038e-025       wub1=-5.8384522e-025      pub1=-3.1367914e-031
+ uc1=-3.5382299e-011       luc1=-1.3697966e-017      wuc1=-5.736108e-018
+ puc1=1.7015614e-023       prt=0                     at=373669.54
+ lat=-0.20256884           wat=-0.11337488           pat=1.3224091e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     12: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.0021752367+dvth0n_na                        lvth0=-1.003713e-008+dlvth0n_na
+ wvth0=1.222165e-008+dwvth0n_na                      pvth0=4.2622712e-015
+ k1=0.042                  k2=-0.0067757214+dk2n_na  lk2=4.7342822e-009
+ wk2=8.8875357e-009+dwk2n_na                         pk2=-3.4307544e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.076380358         lvoff=2.0888574e-009+dlvoffn_na
+ wvoff=-7.7446123e-009     pvoff=1.8170735e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.053901714+du0n_na    wu0=3.8486905e-009        ua=6.8485116e-010
+ lua=1.6820943e-016        wua=-8.0018125e-020       pua=9.9976432e-023
+ ub=1.8103891e-018         lub=-1.2670354e-025       wub=4.9619814e-025
+ pub=-2.5386686e-031       uc=-6.3310217e-011        luc=1.5392919e-017
+ wuc=-3.3329606e-017       puc=1.6053059e-023        vsat=230760.85
+ lvsat=0.0038947956        wvsat=-0.0023079146       pvsat=2.6919608e-009
+ a0=9.5685352              la0=-3.9963991e-006       wa0=-4.1941282e-006
+ pa0=1.9561582e-012        ags=-1.8796554            lags=3.0412731e-006
+ wags=1.2189975e-006       pags=5.0848148e-013       a1=0
+ a2=0.2021                 b0=0                      b1=0
+ keta=-0.0043770989        lketa=-9.6730187e-009     wketa=-1.5195561e-008
+ pketa=8.0355029e-015      dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.038843752
+ lpdiblc2=5.9582269e-009   wpdiblc2=-2.0297315e-008  ppdiblc2=2.7353312e-015
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.29683264
+ lkt1=-2.7244305e-008      wkt1=-3.2517232e-008      pkt1=8.7040065e-015
+ kt1l=0                    kt2=-0.01486              ute=-1.782
+ ua1=-3.3613987e-010       lua1=7.0474714e-016       wua1=6.3377654e-016
+ pua1=-2.7930589e-022      ub1=-3.4096093e-019       lub1=-1.3078146e-024
+ wub1=-1.3100612e-024      pub1=5.3338212e-031       uc1=-7.4575817e-011
+ luc1=3.201751e-017        wuc1=2.705887e-017        puc1=-2.1236579e-023
+ prt=0                     at=246640.4               lat=-0.054401549
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lu0=0+dlu0n_na            saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pu0=0+dpu0n_na            fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.019665613+dvth0n_na                         wvth0=3.9394153e-009+dwvth0n_na
+ k1=0.042                  k2=0.0065262484+dk2n_na   wk2=2.0976371e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.061093484         wvoff=-7.7569931e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.050007742+du0n_na    wu0=3.2490023e-009        ua=1.4384007e-009
+ wua=-1.4661123e-016       ub=1.0413548e-019         wub=6.8635174e-025
+ uc=-6.3913576e-011        wuc=-1.7133208e-017       vsat=234100
+ a0=5.7009523              wa0=-8.5936111e-007       ags=0.78905936
+ wags=2.3474042e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.047126916
+ wketa=5.4908139e-009      dwg=0                     dwb=0
+ pclm=0.75172671           wpclm=1.1209058e-008      pdiblc1=0
+ pdiblc2=-0.0093686673     wpdiblc2=6.9696379e-009   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.32745452           wkt1=-1.2386821e-008
+ kt1l=0                    kt2=-0.021113445          wkt2=-1.445806e-009
+ ute=-1.782                ua1=2.1538758e-010        wua1=8.3966404e-017
+ ub1=-1.1078328e-018       wub1=-3.8098614e-025      uc1=-9.0507994e-011
+ wuc1=2.7385435e-017       prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvth0n_na        lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ lvoff=0+dlvoffn_na        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     14: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035827019+dvth0n_na                         lvth0=1.6107111e-007+dlvth0n_na
+ wvth0=6.245616e-009+dwvth0n_na                      pvth0=-2.2984527e-014
+ k1=0.042                  k2=0.0030951675+dk2n_na   lk2=3.4195539e-008
+ wk2=3.3823974e-009+dwk2n_na                         pk2=-1.280444e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052420315         lvoff=-8.6440309e-008+dlvoffn_na
+ wvoff=-1.1030421e-008     pvoff=3.2624307e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05138213+du0n_na     lu0=-1.3697709e-008+dlu0n_na
+ wu0=2.0442706e-009        pu0=1.2006843e-014+dpu0n_na
+ ua=2.0784924e-009         lua=-6.3794127e-015       wua=-3.6224099e-016
+ pua=2.1490533e-021        ub=-9.747155e-019         lub=1.0752265e-023
+ wub=9.8799934e-025        pub=-3.0063419e-030       uc=-7.7461161e-011
+ luc=1.350207e-016         wuc=-1.438401e-017        puc=-2.7399615e-023
+ vsat=232735.1             lvsat=0.013603157         wvsat=0.00074004946
+ pvsat=-7.3756319e-009     a0=5.5422428              la0=1.5817625e-006
+ wa0=-7.7330885e-007       pa0=-8.5763162e-013       ags=1.0058056
+ lags=-2.1601807e-006      wags=9.5852065e-008       pags=1.3842174e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.040026307         lketa=-7.0767536e-008
+ wketa=3.8420526e-009      pketa=1.6432222e-014      dwg=0
+ dwb=0                     pclm=0.74296595           lpclm=8.7313289e-008
+ wpclm=1.5959143e-008      ppclm=-4.7341266e-014     pdiblc1=0
+ pdiblc2=-0.019522161      lpdiblc2=1.0119382e-007   wpdiblc2=9.5877436e-009
+ ppdiblc2=-2.6093099e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.2890693            lkt1=-3.8256257e-007      wkt1=-2.6191325e-008
+ pkt1=1.3758127e-013       kt1l=0                    kt2=-0.02376348
+ lkt2=2.6411319e-008       wkt2=-2.0584982e-009      pkt2=6.1063371e-015
+ ute=-1.782                ua1=-1.4873088e-010       lua1=3.6289517e-015
+ wua1=2.3388666e-016       pua1=-1.4941658e-021      ub1=3.102742e-019
+ lub1=-1.4133428e-023      wub1=-8.3153858e-025      pub1=4.4903876e-030
+ uc1=-9.9215112e-011       luc1=8.6778654e-017       wuc1=3.2106434e-017
+ puc1=-4.7051386e-023      prt=0                     at=374183.75
+ lat=-0.73934522           wat=-0.012305474          pat=1.2264132e-007
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     15: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.023161032+dvth0n_na                          lvth0=-1.3911287e-008+dlvth0n_na
+ wvth0=-5.0291428e-009+dwvth0n_na                    pvth0=1.0460962e-014
+ k1=0.042                  k2=0.017369029+dk2n_na    lk2=-8.1464998e-009
+ wk2=-7.8934462e-010+dwk2n_na                        pk2=-4.2936785e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084779302         lvoff=9.5495215e-009+dlvoffn_na
+ wvoff=3.2518727e-009      pvoff=-9.7427467e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.042879011+du0n_na    lu0=1.1525977e-008+dlu0n_na
+ wu0=7.1445597e-009        pu0=-3.1226752e-015+dpu0n_na
+ ua=-8.5560538e-010        lua=2.3243066e-015        wua=6.4968384e-016
+ pua=-8.5272454e-022       ub=3.4651675e-018         lub=-2.418222e-024
+ wub=-3.3132034e-025       pub=9.0729329e-031        uc=-6.0078563e-012
+ luc=-7.6938667e-017       wuc=-3.392692e-017        puc=3.0572552e-023
+ vsat=239407.95            lvsat=-0.0061912134       wvsat=-0.0028779701
+ pvsat=3.3568759e-009      a0=9.0403821              la0=-8.7951318e-006
+ wa0=-1.7508767e-006       pa0=2.0422296e-012        ags=-1.5260194
+ lags=5.3502349e-006       wags=6.7433082e-007       pags=-3.3178424e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.091514384         lketa=8.19669e-008
+ wketa=1.7831886e-008      pketa=-2.5067276e-014     dwg=0
+ dwb=0                     pclm=0.8343338            lpclm=-1.8372066e-007
+ wpclm=-3.3580504e-008     ppclm=9.961334e-014       pdiblc1=0
+ pdiblc2=0.018553398       lpdiblc2=-1.1753668e-008  wpdiblc2=4.7336555e-010
+ ppdiblc2=9.4382859e-016   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.47930556           lkt1=1.8175503e-007       wkt1=4.835032e-008
+ pkt1=-8.3539369e-014      kt1l=0                    kt2=-0.01486
+ ute=-1.782                ua1=9.22964e-010          lua1=4.4987173e-016
+ wua1=-3.3455707e-016      pua1=1.9206795e-022       ub1=-4.9246222e-018
+ lub1=1.3953901e-024       wub1=8.8069215e-025       pub1=-5.8878042e-031
+ uc1=-9.980334e-011        luc1=8.8523574e-017       wuc1=2.919298e-017
+ puc1=-3.8408905e-023      prt=0                     at=65872.311
+ lat=0.17523107            wat=0.053512777           pat=-7.2602199e-008
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     16: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.020835647+dvth0n_na                          lvth0=-1.1198948e-008+dlvth0n_na
+ wvth0=-2.5485058e-010+dwvth0n_na                    pvth0=4.8922085e-015
+ k1=0.042                  k2=0.011276519+dk2n_na    lk2=-1.0401727e-009
+ wk2=-9.0038917e-010+dwk2n_na                        pk2=-2.9984504e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.094701242         lvoff=2.1122512e-008+dlvoffn_na
+ wvoff=2.1889711e-009      pvoff=-8.502974e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052760645+du0n_na    wu0=4.4673782e-009        ua=1.0203154e-009
+ lua=1.3622514e-016        wua=-1.8196871e-016       pua=1.1731832e-022
+ ub=1.3457674e-018         lub=5.3854776e-026        wub=7.4811601e-025
+ pub=-3.5176557e-031       uc=-1.1618645e-010        luc=5.1574084e-017
+ wuc=-4.6601134e-018       puc=-3.5643684e-024       vsat=247565.19
+ lvsat=-0.015705853        wvsat=-0.011419227        pvsat=1.3319432e-008
+ a0=1.8331457              la0=-3.8858249e-007       ags=-2.7302665
+ lags=6.7548736e-006       wags=1.6801988e-006       pags=-1.5050327e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.010493704         lketa=-1.2535946e-008
+ wketa=-1.1879138e-008     pketa=9.5877818e-015      dwg=0
+ dwb=0                     pclm=0.67682348           wpclm=5.1821587e-008
+ pdiblc1=0                 pdiblc2=0.0074486026      lpdiblc2=1.1990091e-009
+ wpdiblc2=-3.2748645e-009  ppdiblc2=5.3157791e-015   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.29242568           lkt1=-3.6222407e-008
+ wkt1=-3.4906685e-008      pkt1=1.3571933e-014       kt1l=0
+ kt2=-0.01486              ute=-1.782                ua1=8.1267718e-010
+ lua1=5.7851072e-016       wua1=1.0887941e-017       pua1=-2.108605e-022
+ ub1=-2.9685052e-018       lub1=-8.8623267e-025      wub1=1.1459327e-025
+ pub1=3.0480037e-031       uc1=-1.3187543e-011       luc1=-1.2505437e-017
+ wuc1=-6.2258524e-018      puc1=2.9037625e-024       prt=0
+ at=278465.42              lat=-0.072738381          wat=-0.017255524
+ pat=9.9422302e-009        jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     } 
endsection mos_na
// 

section mos_3vna
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V Native NMOS DEVICE MODELS          
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt nanch3_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-7 dmci=3.15e-007 xw= + 0 + 
+ dxwn_3vna ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg 
+ + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + 
+ (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) 
+ * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_3vna 
+ temp1=parn1_3vna temp2=parn2_3vna fac1=0.791128 * temp1 * sigma + 0.624370 * temp2 
+ * sigma fac2=0.791128 * temp1 * sigma - 0.624370 * temp2 * sigma lef=l * factor 
+ - 1.5e-08 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisn_3vna= - 0.00244288 * geo_fac * fac1 * mismatchflag dlmisn_3vna=0.00137060 
+ * geo_fac * lef * fac2 * mismatchflag dwmisn_3vna= - 0.00137060 * geo_fac * wef 
+ * fac2 * mismatchflag toxmisn_3vna=0.00137060 * geo_fac * toxn_3vna * fac2 * mismatchflag 
nanch3_mac ( n1 n2 n3 n4 ) nanch3 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nanch3 bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln_3vna+dlmisn_3vna)                 lmax=0.00090001
+ wmin=1.003e-005-(dxwn_3vna+dwmisn_3vna)             wmax=0.00090001
+ version=4.5               gbmin=1.00e-12            tempmod=0
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=1
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tnom=25                   toxe=(toxn_3vna+toxmisn_3vna)
+ toxm=6.693e-009           dtox=5.5408e-010          epsrox=3.9
+ wint=2.36e-008            lint=2.027e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_3vna+dlmisn_3vna)                 xw=0+(dxwn_3vna+dwmisn_3vna)
+ dlc=dlcn_3vna             dwc=0                     xpart=1
+ toxref=3e-009             vth0=-0.0765+(dvthn_3vna+vthmisn_3vna)
+ k1=0.072                  k2=0.001331+dk2n_3vna     k3=-2.584
+ k3b=1.844e-010            w0=0                      dvt0=37.335
+ dvt1=0.3996               dvt2=0.096                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.07
+ minv=-0.5                 voffl=-2.6873e-010        dvtp0=1e-010
+ dvtp1=3.3836              lpe0=1e-010               lpeb=8.1978e-011
+ xj=1.4e-007               ngate=9.445e+019          ndep=1e+016
