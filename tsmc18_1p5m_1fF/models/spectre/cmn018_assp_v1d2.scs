//
simulator lang=spectre insensitive=yes
library tsmclib
// *******************************************************************************
//   **********************************************
//   *      TSMC SPICE MODEL --- Security B       *
//   **********************************************
//  
//     PROCESS :  TSMC 0.18um Mixed Signal SALICIDE (1.8V/3.3V)
//     MODEL   :  BSIM4 ( V4.5 )
//     DOC. NO.:  T-018-CM-SP-007
//     VERSION :  V1.2           
//     DATE    :  10:11AM, Jun. 21, 2010
//     SPECTRE VERSION : 7.1.0.048 
// 
// ******************************************************************************* 
//                  
// *****************************************************************************
//                                                                            
//   * 
//        IN THIS MODEL LIB CONTAINS :                                        
//   *  
//        1.LIB stat                                                          
//   *
//    ( Common statistical library )                                          
//   *
//                                                                            
//   *
//        2.LIB MC                                                            
//   *
//    ( 1.8V Std-Vt statistical models with different device geometries)      
//   *
//                                                                            
//   *
//        3.LIB MC_3V                                                         
//   *
//    ( 3.3V Std-Vt statistical models with different device geometries)      
//   *
//                                                                            
//   *
//        4.LIB MC_M                                                          
//   *
//    ( 1.8V Med-Vt statistical models with different device geometries)      
//   *
//                                                                            
//   *
//        5.LIB MC_3M                                                         
//   *
//    ( 3.3V Med-Vt statistical models with different device geometries)      
//   *
//                                                                            
//   *
//        6.LIB MC_na                                                         
//   *
//    ( 1.8V Native device statistical models with different device           
//   *
//      geometries)                                                           
//   *
//                                                                            
//   *
//        7.LIB MC_3VNA                                                       
//   *
//    ( 3.3V Native device statistical models with different devic            
//   *
//      geometries)                                                           
//   *
//                                                                            
//   *
//        8.LIB TT                                                            
//   *
//              SS                                                            
//   *
//              FF                                                            
//   *
//              SF                                                            
//   *
//              FS                                                            
//   *
//          Model name    length range         width range     unit           
//   *
//                        low     high         low    high                    
//   *
//           ----------------------------------------------------------       
//   *
//             nch        0.18   20.0           0.22    900      um           
//   *
//           ----------------------------------------------------------       
//   *
//             pch        0.18   20.0           0.22    900      um           
//   *
//           ----------------------------------------------------------       
//   *
//         ( 1.8V Normal devices with different geometric and corner models)  
//   *
//                                                                            
//   *
//        9.LIB TT_3V                                                         
//   *
//              SS_3V                                                         
//   *
//              FF_3V                                                         
//   *
//              SF_3V                                                         
//   *
//              FS_3V                                                         
//   *
//          Model name    length range         width range     unit           
//   *
//                        low     high         low    high                    
//   *
//           ----------------------------------------------------------       
//   *
//             nch3       0.35  20.0           0.22    900      um            
//   *
//             pch3       0.30  20.0           0.22    900      um            
//   *
//           ----------------------------------------------------------       
//   *
//         ( 3.3V normal devices  with different                              
//   *
//           geometric and corner models)                                     
//   *
//                                                                            
//   *
//       10.LIB TT_M                                                          
//   *
//              SS_M                                                          
//   *
//              FF_M                                                          
//   *
//              SF_M                                                          
//   *
//              FS_M                                                          
//   *
//          Model name    length range         width range     unit           
//   *
//                        low     high         low    high                    
//   *
//           ----------------------------------------------------------       
//   *
//             mench      0.30  20.0           0.22    900      um            
//   *
//             mepch      0.25  20.0           0.22    900      um            
//   *
//           ----------------------------------------------------------       
//   *
//         ( 1.8V Medium Vt devices with different geometric and corner models)*
//                                                                            
//   *
//       11.LIB TT_3M                                                         
//   *
//              SS_3M                                                         
//   *
//              FF_3M                                                         
//   *
//              SF_3M                                                         
//   *
//              FS_3M                                                         
//   *
//          Model name    length range         width range     unit           
//   *
//                        low     high         low    high                    
//   *
//           ----------------------------------------------------------       
//   *
//             mench3     0.6   10.0           0.22    900      um            
//   *
//           ----------------------------------------------------------       
//   *
//         ( 3.3V Medium Vt NMOS with different geometric and corner models)  
//   *
//                                                                            
//   *
//       12.LIB TT_na                                                         
//   *
//              SS_na                                                         
//   *
//              FF_na                                                         
//   *
//              SF_na                                                         
//   *
//              FS_na                                                         
//   *
//          Model name    length range         width range     unit           
//   *
//                        low     high         low    high                    
//   *
//           ----------------------------------------------------------       
//   *
//             nanch      0.5   20.0           0.22    900      um            
//   *
//           ----------------------------------------------------------       
//   *
//         ( 1.8V native NMOS with different geometric and corner models)     
//   *
//                                                                            
//   *
//       13.LIB TT_3Vna                                                       
//   *
//              SS_3Vna                                                       
//   *
//              FF_3Vna                                                       
//   *
//              SF_3Vna                                                       
//   *
//              FS_3Vna                                                       
//   *
//          Model name    length range         width range     unit           
//   *
//                        low     high         low    high                    
//   *
//           ----------------------------------------------------------       
//   *
//             nanch3     1.2   20.0           0.22    900      um            
//   *
//           ----------------------------------------------------------       
//   *
//         ( 3.3V native NMOS with different geometric and corner models)     
//   *
//                                                                            
//   *
//        14.LIB mc_bip                                                       
//   *
//    ( 1.8V P+/NW/PSUB 10x10, 5x5, and 2x2 vertical PNP bipolar statistical  
//   *
//      model)                                                                
//   *
//                                                                            
//   *
//        15.LIB TT_BIP                                                       
//   *
//               SS_BIP                                                       
//   *
//               FF_BIP                                                       
//   *
//             Model name      emitter area      base area         unit       
//   *
//           ------------------------------------------------------------     
//   *
//               pnp10            10x10            16x16           um^2       
//   *
//               pnp5              5x5             11x11           um^2       
//   *
//               pnp2              2x2              8x8            um^2       
//   *
//               npn10            10x10            16x16           um^2       
//   *
//               npn5              5x5             11x11           um^2       
//   *
//               npn2              2x2              8x8            um^2       
//   *
//           ------------------------------------------------------------     
//   *
//         ( 1.8V P+/NW/PSUB 10x10, 5x5 and 2x2 vertical PNP bipolar and      
//   *
//                N+/PW/DNW  10x10, 5x5  and 2x2 vertical NPN bipolar )       
//   *
//                                                                            
//   *
//       16.LIB TT_BIP3                                                       
//   *
//              SS_BIP3                                                       
//   *
//              FF_BIP3                                                       
//   *
//             Model name      emitter area      base area         unit       
//   *
//           ------------------------------------------------------------     
//   *
//               pnp10_3          10x10            16x16           um^2       
//   *
//               pnp5_3            5x5             11x11           um^2       
//   *
//               pnp2_3            2x2              8x8            um^2       
//   *
//           ------------------------------------------------------------     
//   *
//         ( 3.3V P+/NW/PSUB 10x10, 5x5 and 2x2 vertical PNP bipolar )        
//   *
//                                                                            
//   *
//       17.LIB DIO                                                           
//   *
//         ( 1.8V P+/NW , N+/PW & NW/PSUB diode )                             
//   *
//                                                                            
//   *
//       18.LIB DIO3                                                          
//   *
//         ( 3.3V P+/NW , N+/PW , NW/PSUB & ESD diode )                       
//   *
//                                                                            
//   *
//       19.LIB DIO_M                                                         
//   *
//         ( 1.8V Medium Vt P+/NW , N+/PW & NW/PSUB diode )                   
//   *
//                                                                            
//   *
//       20.LIB DIO_3M                                                        
//   *
//         ( 3.3V Medium Vt P+/NW , N+/PW & NW/PSUB diode )                   
//   *
//                                                                            
//   *
//       21.LIB DIO_DNW                                                       
//   *
//         ( DNWPSUB & PWDNW diode )                                          
//   *
//                                                                            
//   *
//       22.LIB RES                                                           
//   *
//          (2T resist model)                                                 
//   *
//  Model name      structure                                                 
//   *
//  -----------------------------------------                                 
//   *
//   rnod         N+diff w/i silicide W>2um                                   
//   *
//   rnodw        N+diff w/i silicide 0.22um<W<2um                            
//   *
//   rpod         P+diff w/i silicide W>2um                                   
//   *
//   rpodw        P+diff w/i silicide 0.22um<W<2um                            
//   *
//   rnodrpo      N+diff w/o silicide 2um<=W                                  
//   *
//   rpodrpo      P+diff w/o silicide 2um<=W                                  
//   *
//   rnwod        NW diff(under OD)                                           
//   *
//   rnwsti       NW diff(under STI)                                          
//   *
//   rnpo1        N+Poly w/i silicide W>2um                                   
//   *
//   rnpo1w       N+Poly w/i silicide 0.18um<W<2um                            
//   *
//   rppo1        P+Poly w/i silicide W>2um                                   
//   *
//   rppo1w       P+Poly w/i silicide 0.18um<W<2um                            
//   *
//   rnpo1rpo     N+Poly w/o silicide 2um<W                                   
//   *
//   rppo1rpo     P+Poly w/o silicide 2um<W                                   
//   *
//   rm1          Metal 1 with W/S=0.23/0.23                                  
//   *
//   rm2~5        Metal 2 to 5 with W/S=0.28/0.28                             
//   *
//   rm6          Metal 6 with W/S=0.44/0.46                                  
//   *
//   rppolyhri    P-Poly w/o silicide 2um<W                                   
//   *
//                                                                            
//   *
//       23.LIB DISRES                                                        
//   *
//          (3T 5section resist model)                                        
//   *
//                                                                            
//   *
//       25.LIB  MC_BBMVAR                                                    
//   *
//    ( 1.8V /3.3V Standard-Vt NMOS in N-Well varactor statistical model)     
//   *
//                                                                            
//   *
//       26.LIB  TT_BBMVAR                                                    
//   *
//               SS_BBMVAR                                                    
//   *
//               FF_BBMVAR                                                    
//   *
//     ( 1.8V /3.3V Standard-Vt NMOS in N-Well varactor )                     
//   *
//                                                                            
//   *
//       27.LIB MIM                                                           
//   *
//         ( MiM Capacitance model )                                          
//   *
//                                                                            
//   *
//       28.LIB RTMOM                                                         
//   *
//         ( RTMON Capacitance model )                                        
//   *
//                                                                            
//   *
//       29.LIB FMOM                                                          
//   *
//         ( FMOM Capacitance model )                                         
//   *
//                                                                            
//   *
// *****************************************************************************
// ************************    FLAG FOR MISMATCH ******************
// 
//  NOTE: 
//   1. Mismatch effect is included in this model. User can use mismatchflag to 
//  
//      turn on or turn off this effect.
// 
// ***********************************************************************************************
// **********************     FLAG FOR FLICKER NOISE CORNERS SIMULATION  ************************
// 
//  NOTE:
//   1. Transistor
//      noiseflagn=0 for typical, noiseflagn=1 for worstcase, noiseflagn=-1 for 
//  best case
//      noiseflagp=0 for typical, noiseflagp=1 for worstcase, noiseflagp=-1 for 
//  best case
//   2. Resistor
//      rnoiseflag=0 for typical, rnoiseflag=1 for worstcase, rnoiseflag=-1 for 
//  best case
// 
// **********************************************************************************************
// 
// *****************************************************************************
//                                                                            
//   *
//  1)To use these models directly by programming in this style:              
//   *
//                                                                            
//   *
//      .lib 'cmn018_assp_v1d2.scs' model_name                                  
//   *
//                                                                            
//   *
//                                                                            
//   *
//     EX: .lib 'cmn018_assp_v1d2.scs' TT                                       
//   *
//         for typical 1.8V N,PMOS                                            
//   *
//         .lib 'cmn018_assp_v1d2.scs' TT_33              			     *
//         for typical 3.3V N,PMOS                                            
//   *
//   note:                                                                    
//   *
//       corner_name                                                          
//   *
//        TT : typical model for 1.8V devices                                 
//   *
//        SS : Slow NMOS Slow PMOS model for 1.8V devices                     
//   *
//        FF : Fast NMOS Fast PMOS model for 1.8V devices                     
//   *
//        SF : Slow NMOS Fast PMOS model for 1.8V devices                     
//   *
//        FS : Fast NMOS Slow PMOS model for 1.8V devices                     
//   *
//                                                                            
//   *
//        TT_3V : typical model for 3.3V devices                              
//   *
//        SS_3V : Slow NMOS Slow PMOS model for 3.3V devices                  
//   *
//        FF_3V : Fast NMOS Fast PMOS model for 3.3V devices                  
//   *
//        SF_3V : Slow NMOS Fast PMOS model for 3.3V devices                  
//   *
//        FS_3V : Fast NMOS Slow PMOS model for 3.3V devices                  
//   *
//                                                                            
//   *
//        TT_M : typical model for 1.8V devices                               
//   *
//        SS_M : Slow NMOS Slow PMOS model for 1.8V medium vt devices         
//   *
//        FF_M : Fast NMOS Fast PMOS model for 1.8V medium vt devices         
//   *
//        SF_M : Slow NMOS Fast PMOS model for 1.8V medium vt devices         
//   *
//        FS_M : Fast NMOS Slow PMOS model for 1.8V medium vt devices         
//   *
//                                                                            
//   *
//        TT_3M : typical model for 3.3V devices                              
//   *
//        SS_3M : Slow NMOS Slow PMOS model for 3.3V medium vt devices        
//   *
//        FF_3M : Fast NMOS Fast PMOS model for 3.3V medium vt devices        
//   *
//        SF_3M : Slow NMOS Fast PMOS model for 3.3V medium vt devices        
//   *
//        FS_3M : Fast NMOS Slow PMOS model for 3.3V medium vt devices        
//   *
//                                                                            
//   *
//        TT_NA : typical model for 1.8V native NMOS                          
//   *
//        SS_NA : Slow NMOS for 1.8V native NMOS                              
//   *
//        FF_NA : Fast NMOS for 1.8V native NMOS                              
//   *
//        SF_NA : Slow NMOS for 1.8V native NMOS                              
//   *
//        FS_NA : Fast NMOS for 1.8V native NMOS                              
//   *
//                                                                            
//   *
//        TT_3VNA : typical model for 3.3V native NMOS                        
//   *
//        SS_3VNA : Slow NMOS for 3.3V native NMOS                            
//   *
//        FF_3VNA : Fast NMOS for 3.3V native NMOS                            
//   *
//        SF_3VNA : Slow NMOS for 3.3V native NMOS                            
//   *
//        FS_3VNA : Fast NMOS for 3.3V native NMOS                            
//   *
//                                                                            
//   *
//  2)HDIF depends on your layout poly spacer to contact center distance.     
//   *
//    The value listed here is TSMC minimum-rule value. You can change it     
//   *
//    according to your layout.                                               
//   *
//                                                                            
//   *
// ***************************************************************************** 
//  
// *********************************************************************************** 
//     
// *********************** Statistical Model Usage ***********************************
// 
//  Monte Carlo simulation can be done by setting "MONTE=val" in netlist. 
//  It produces a number (val) of randomly generated values. 
//  The following netlist is an example to show how to use statistical model in 
//  
//  HSPICE format for an Idsat 500-trail simulation :
// 
//      .option  nopage nomod
//      +        newtol numdgt=7 relmos=1e-4 absmos=1e-8 relv=1e-4 relvdc=1e-4 
//  ingold=2 gmindc=1e-18
// 
//      .temp 25.000
//      .lib 'cmn018_assp_v1d2.scs' stat
//      .lib 'cmn018_assp_v1d2.scs' MC
// 
//      Vgs g 0 1.0
//      Vss s 0 0
//      Vbs b 0 0
//      Vds1 d1 0 1.0
//      Vds2 d2 0 1.0
//      mdut1 d1 g s b nch w=10u l=0.18u
//      xmdut2 d2 g s b nch_mac w=10u l=0.1u sc=20u wpeflag=1 rgflag=1 mismatchflag=1
//      .op
//      .dc vgs 0 1.000000 1.0000 MONTE=500
//      .end
// 
//  The following netlist is an example to show how to use statistical model in 
//  
//  HSPICE format for an Idsat 25 sample simulation :
// 
//      .option  nopage nomod
//      +        newtol numdgt=7 relmos=1e-4 absmos=1e-8 relv=1e-4 relvdc=1e-4 
//  ingold=2 gmindc=1e-18
// 
//      .temp 25.000
// 
//      Vgs g 0 1.0
//      Vss s 0 0
//      Vbs b 0 0
//      Vds1 d1 0 1.0
//      Vds2 d2 0 1.0
//      mdut1 d1 g s b nch w=10u l=0.18u
//      xmdut2 d2 g s b nch_mac w=10u l=0.1u sc=20u wpeflag=1 rgflag=1
//      .op
//      .dc vgs 0 1.000000 1.0000
//      .lnc 'lhs_svt.spf'
//      .end
// 
// ***********************************************************************************
// *********************** Miamtch Model Usage ***********************************
// 
//  Monte Carlo simulation can be done by setting "MONTE=val" in netlist. 
//  It produces a number (val) of randomly generated values. 
//  The following netlist is an example to show how to use statistical model in 
//  
//  HSPICE format for an Idsat 1000-trail simulation :
// 
//      .option  nopage nomod
//      +        newtol numdgt=7 relmos=1e-4 absmos=1e-8 relv=1e-4 relvdc=1e-4 
//  ingold=2 gmindc=1e-18
// 
//      .temp 25.000
//      .lib 'cmn018_assp_v1d2.scs' TT
// 
//      Vgs g 0 1.8
//      Vss s 0 0
//      Vbs b 0 0
//      Vds1 d1 0 1.8
//      Vds2 d2 0 1.8
//      mdut1 d1 g s b nch w=10u l=0.18u
//      xmdut2 d2 g s b nch_mac w=10u l=0.18u mismatchflag=1
//      .op
//      .dc vgs 0 1.8000000 1.80000 MONTE=1000
//      .end
// *********************************************************************************** 
//     
 
 
section stat_mis 
statistics { 
 mismatch { 
  vary parn1 dist=gauss std=1/1 
  vary parn2 dist=gauss std=1/1 
  vary parp1 dist=gauss std=1/1 
  vary parp2 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis 
 
section stat_mis_3v 
statistics { 
 mismatch { 
  vary parn1_3V dist=gauss std=1/1 
  vary parn2_3V dist=gauss std=1/1 
  vary parp1_3V dist=gauss std=1/1 
  vary parp2_3V dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_3v 
 
section stat_mis_m 
statistics { 
 mismatch { 
  vary parn1m dist=gauss std=1/1 
  vary parn2m dist=gauss std=1/1 
  vary parp1m dist=gauss std=1/1 
  vary parp2m dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_m 
 
section stat_mis_3m 
statistics { 
 mismatch { 
  vary parn1_3M dist=gauss std=1/1 
  vary parn2_3M dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_3m 
 
section stat_mis_na 
statistics { 
 mismatch { 
  vary parn1_na dist=gauss std=1/1 
  vary parn2_na dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_na 
 
section stat_mis_3vna 
statistics { 
 mismatch { 
  vary parn1_3VNA dist=gauss std=1/1 
  vary parn2_3VNA dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_3vna 
 
section stat_mis_bip 
statistics { 
 mismatch { 
  vary par_bjtp1 dist=gauss std=1/1 
  vary par_bjtp2 dist=gauss std=1/1 
  vary par_bjtn1 dist=gauss std=1/1 
  vary par_bjtn2 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_bip 
 
section stat_mis_res 
statistics { 
 mismatch { 
  vary par_res dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_res 
 
section stat_mis_disres 
statistics { 
 mismatch { 
  vary par_res_dis dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_disres 
 
section stat_mis_mim 
statistics { 
 mismatch { 
  vary par_mim dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_mim 
 
section stat_mis_rtmom 
statistics { 
 mismatch { 
  vary par_mom dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rtmom 
 
section stat_mis_fmom 
statistics { 
 mismatch { 
  vary par_fmom dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_fmom 
 
 

section setup
parameters noiseflagn=0
parameters noiseflagp=0
parameters ccoflag=1
parameters mismatchflag_mos=1
 
endsection setup
 

section setup_m
parameters noiseflagn_m=0
parameters noiseflagp_m=0
parameters ccoflag_m=1
parameters mismatchflag_mos_m=1
 
endsection setup_m
 

section setup_na
parameters noiseflagn_na=0
parameters ccoflag_na=1
parameters mismatchflag_mos_na=1
 
endsection setup_na
 

section setup_3v
parameters noiseflagn_3v=0
parameters noiseflagp_3v=0
parameters ccoflag_3v=1
parameters mismatchflag_mos_3v=1
 
endsection setup_3v
 

section setup_3m
parameters noiseflagn_3m=0
parameters ccoflag_3m=1
parameters mismatchflag_mos_3m=1
 
endsection setup_3m
 

section setup_3vna
parameters noiseflagn_3vna=0
parameters ccoflag_3vna=1
parameters mismatchflag_mos_3vna=1
 
endsection setup_3vna
 

section setup_bip
parameters mismatchflag_bip=1
endsection setup_bip
 

section setup_res
parameters rnoiseflag_res=0
parameters mismatchflag_res=0
endsection setup_res
 

section setup_disres
parameters rnoiseflag_disres=0
parameters mismatchflag_disres=0
endsection setup_disres
 

section setup_rtmom
parameters mismatchflag_rtmom=0
endsection setup_rtmom
 

section setup_fmom
parameters mismatchflag_fmom=0
endsection setup_fmom
 

section setup_mim
parameters mismatchflag_mim=0
endsection setup_mim
 
// **************************   LIBRARY OF statistical CORNER CASE            
//  ***************************

section stat
parameters random1=0
parameters random2=0
parameters random3=0
parameters random4=0
parameters random6=0
parameters random7=0
parameters random8=0
parameters random9=0
parameters par1=random1
parameters par2=random2
parameters par3=random3
parameters par4=random4
parameters par6=random6
parameters par7=random7
parameters par8=random8
parameters par9=random9

statistics {
    process {
        vary random1 dist=gauss std=1/3
        vary random2 dist=gauss std=1/3
        vary random3 dist=gauss std=1/3
        vary random4 dist=gauss std=1/3
        vary random6 dist=gauss std=1/3
        vary random7 dist=gauss std=1/3
        vary random8 dist=gauss std=1/3
        vary random9 dist=gauss std=1/3
        }
    }
 
endsection stat
 
// *****************************   LIBRARY OF mote carlo CORNER CASE   *******************************

section mc
include "cmn018_assp_v1d2.scs" section=setup
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters a1=par1 * 5.6861e+000 * 3 / 2.0
parameters a2=par2 * 4.0564e+000 * 3 / 2.0
parameters a3=par3 * 1.8916e+000 * 3 / 2.0
parameters a4=par4 * 1.2793e+000 * 3 / 2.0
parameters toxn=3.9810e-009 + ( - 1.0516e-011) * a1 + ( - 1.0505e-012) * a2 + ( 
+ - 9.1138e-012) * a3 + (1.5152e-011) * a4
parameters dxln=0.0000e+000 + ( - 1.2907e-009) * a1 + (1.2252e-010) * a2 + ( - 4.8864e-010) 
+ * a3 + (2.9622e-010) * a4
parameters dxwn=0.0000e+000 + (1.6720e-009) * a1 + ( - 1.5955e-009) * a2 + (3.1424e-009) 
+ * a3 + ( - 4.1658e-009) * a4
parameters dvthn=0.0000e+000 + ( - 2.3864e-003) * a1 + (4.2262e-003) * a2 + ( - 
+ 1.3560e-003) * a3 + ( - 2.5226e-003) * a4
parameters dlvthn=0.0000e+000 + ( - 1.5975e-010) * a1 + (2.5351e-010) * a2 + ( - 
+ 1.7981e-011) * a3 + ( - 1.2319e-010) * a4
parameters dwvthn=0.0000e+000 + ( - 1.9462e-010) * a1 + (3.2114e-010) * a2 + ( - 
+ 5.2352e-011) * a3 + ( - 1.6918e-010) * a4
parameters dpvthn=0.0000e+000 + ( - 6.3637e-017) * a1 + (1.1270e-016) * a2 + ( - 
+ 3.6159e-017) * a3 + ( - 6.7268e-017) * a4
parameters dleta0n=0.0000e+000 + ( - 2.6913e-010) * a1 + (5.3546e-010) * a2 + ( 
+ - 2.9851e-010) * a3 + ( - 3.7585e-010) * a4
parameters dlpclmn=0.0000e+000 + (1.5909e-009) * a1 + ( - 2.8175e-009) * a2 + (9.0397e-010) 
+ * a3 + (1.6817e-009) * a4
parameters dlvoffn=0.0000e+000 + (1.0765e-010) * a1 + ( - 2.1418e-010) * a2 + (1.1940e-010) 
+ * a3 + (1.5034e-010) * a4
parameters dpvoffn=0.0000e+000 + (2.4169e-017) * a1 + ( - 4.3391e-017) * a2 + (1.5189e-017) 
+ * a3 + (2.6461e-017) * a4
parameters dcitn=0.0000e+000 + (1.5909e-005) * a1 + ( - 2.8175e-005) * a2 + (9.0397e-006) 
+ * a3 + (1.6817e-005) * a4
parameters dlcitn=0.0000e+000 + ( - 7.1592e-012) * a1 + (1.2679e-011) * a2 + ( - 
+ 4.0679e-012) * a3 + ( - 7.5677e-012) * a4
parameters du0n=0.0000e+000 + ( - 3.9773e-005) * a1 + (7.0437e-005) * a2 + ( - 2.2599e-005) 
+ * a3 + ( - 4.2043e-005) * a4
parameters dlvsatn=0.0000e+000 + ( - 5.3560e-005) * a1 + (8.3089e-005) * a2 + ( 
+ - 1.3165e-006) * a3 + ( - 3.8345e-005) * a4
parameters dpvsatn=0.0000e+000 + ( - 1.0229e-011) * a1 + (1.1762e-011) * a2 + (9.9108e-012) 
+ * a3 + ( - 9.4642e-013) * a4
parameters cjn=9.8100e-004 + ( - 3.9057e-006) * a1 + (6.9169e-006) * a2 + ( - 2.2193e-006) 
+ * a3 + ( - 4.1286e-006) * a4
parameters cjswn=1.1850e-010 + ( - 9.2274e-013) * a1 + (1.6341e-012) * a2 + ( - 
+ 5.2431e-013) * a3 + ( - 9.7539e-013) * a4
parameters cjswgn=3.8200e-010 + ( - 3.0387e-012) * a1 + (5.3814e-012) * a2 + ( - 
+ 1.7266e-012) * a3 + ( - 3.2120e-012) * a4
parameters dk2=0.0000e+000 + ( - 1.2186e-003) * a1 + ( - 9.1024e-004) * a2 + (4.5935e-004) 
+ * a3 + ( - 6.0767e-004) * a4
parameters cgon=9.5484e-011 + (8.7862e-013) * a1 + (8.7768e-014) * a2 + (7.6144e-013) 
+ * a3 + ( - 1.2659e-012) * a4
parameters cgln=1.2991e-010 + (1.1954e-012) * a1 + (1.1941e-013) * a2 + (1.0360e-012) 
+ * a3 + ( - 1.7224e-012) * a4
parameters cfn=1.3500e-010 + (1.2422e-012) * a1 + (1.2409e-013) * a2 + (1.0766e-012) 
+ * a3 + ( - 1.7898e-012) * a4 + 3.57e-11 * ccoflag
parameters toxp=4.0600e-009 + ( - 1.0516e-011) * a1 + ( - 1.0505e-012) * a2 + ( 
+ - 9.1138e-012) * a3 + (1.5152e-011) * a4
parameters dxlp=0.0000e+000 + ( - 1.2907e-009) * a1 + (1.2252e-010) * a2 + ( - 4.8864e-010) 
+ * a3 + (2.9622e-010) * a4
parameters dxwp=0.0000e+000 + (2.0087e-009) * a1 + (1.9632e-009) * a2 + (4.7461e-011) 
+ * a3 + ( - 1.1374e-009) * a4
parameters dvthp=0.0000e+000 + (3.6557e-003) * a1 + (2.7307e-003) * a2 + ( - 1.3780e-003) 
+ * a3 + (1.8230e-003) * a4
parameters dlvthp=0.0000e+000 + (4.4219e-010) * a1 + (3.1095e-010) * a2 + ( - 1.9638e-010) 
+ * a3 + (2.0137e-010) * a4
parameters dwvthp=0.0000e+000 + (8.4107e-010) * a1 + (8.3018e-010) * a2 + ( - 7.3110e-012) 
+ * a3 + (6.1911e-010) * a4
parameters ori_dlpdiblc2p=0.0000e+000 + (2.5333e-011) * a1 + (2.1672e-011) * a2 
+ + ( - 5.3325e-012) * a3 + (1.5352e-011) * a4
parameters dlpdiblc2p=((ori_dlpdiblc2p + 0) + sqrt((ori_dlpdiblc2p + 0) * (ori_dlpdiblc2p 
+ + 0) + 1e-26) - 0 - sqrt(1e-26)) * 0.5
parameters dlpclmp=0.0000e+000 + ( - 4.2379e-010) * a1 + ( - 6.9305e-010) * a2 + 
+ ( - 4.1782e-010) * a3 + ( - 5.8368e-010) * a4
parameters dwpclmp=0.0000e+000 + (4.3266e-010) * a1 + ( - 2.4733e-010) * a2 + ( 
+ - 1.0383e-009) * a3 + ( - 3.4849e-010) * a4
parameters dleta0p=0.0000e+000 + (4.7243e-010) * a1 + ( - 7.5903e-011) * a2 + ( 
+ - 8.3591e-010) * a3 + ( - 1.8850e-010) * a4
parameters dweta0p=0.0000e+000 + ( - 3.6974e-010) * a1 + (2.1136e-010) * a2 + (8.8733e-010) 
+ * a3 + (2.9781e-010) * a4
parameters dlcitp=0.0000e+000 + ( - 1.0329e-012) * a1 + ( - 1.6891e-012) * a2 + 
+ ( - 1.0183e-012) * a3 + ( - 1.4225e-012) * a4
parameters dwcitp=0.0000e+000 + ( - 7.3025e-013) * a1 + ( - 1.6474e-012) * a2 + 
+ ( - 1.4152e-012) * a3 + ( - 1.4540e-012) * a4
parameters dpcitp=0.0000e+000 + (2.1673e-018) * a1 + ( - 1.2389e-018) * a2 + ( - 
+ 5.2013e-018) * a3 + ( - 1.7457e-018) * a4
parameters du0p=0.0000e+000 + ( - 2.2715e-005) * a1 + ( - 1.6968e-005) * a2 + (8.5627e-006) 
+ * a3 + ( - 1.1327e-005) * a4
parameters dlu0p=0.0000e+000 + ( - 3.2664e-012) * a1 + ( - 5.3417e-012) * a2 + ( 
+ - 3.2203e-012) * a3 + ( - 4.4987e-012) * a4
parameters dwu0p=0.0000e+000 + (2.2006e-012) * a1 + ( - 1.2580e-012) * a2 + ( - 
+ 5.2811e-012) * a3 + ( - 1.7725e-012) * a4
parameters dvoffp=0.0000e+000 + (3.7734e-004) * a1 + (2.7650e-004) * a2 + ( - 1.5048e-004) 
+ * a3 + (1.8286e-004) * a4
parameters dlvoffp=0.0000e+000 + (1.6434e-010) * a1 + (1.5811e-010) * a2 + ( - 7.7162e-012) 
+ * a3 + (1.1691e-010) * a4
parameters dwvoffp=0.0000e+000 + ( - 1.1793e-010) * a1 + ( - 2.9923e-010) * a2 + 
+ ( - 2.7945e-010) * a3 + ( - 2.6762e-010) * a4
parameters dagsp=0.0000e+000 + ( - 2.0731e-003) * a1 + ( - 1.7815e-003) * a2 + (4.2425e-004) 
+ * a3 + ( - 1.2641e-003) * a4
parameters dlvsatp=0.0000e+000 + ( - 1.5292e-004) * a1 + (7.7648e-005) * a2 + (3.5201e-004) 
+ * a3 + (1.1351e-004) * a4
parameters dwvsatp=0.0000e+000 + ( - 2.2933e-004) * a1 + ( - 1.3996e-004) * a2 + 
+ (1.3455e-004) * a3 + ( - 8.3355e-005) * a4
parameters dk2p=0.0000e+000 + ( - 9.5333e-004) * a1 + ( - 7.1167e-004) * a2 + (3.6007e-004) 
+ * a3 + ( - 4.7496e-004) * a4
parameters dlk2p=0.0000e+000 + ( - 4.6054e-011) * a1 + ( - 2.3048e-011) * a2 + (3.4779e-011) 
+ * a3 + ( - 1.1737e-011) * a4
parameters cjp=1.1200e-003 + ( - 6.7630e-006) * a1 + ( - 5.0519e-006) * a2 + (2.5494e-006) 
+ * a3 + ( - 3.3725e-006) * a4
parameters cjswp=1.3450e-010 + ( - 1.6207e-012) * a1 + ( - 1.2106e-012) * a2 + (6.1093e-013) 
+ * a3 + ( - 8.0819e-013) * a4
parameters cjswgp=4.3600e-010 + ( - 5.3129e-012) * a1 + ( - 3.9687e-012) * a2 + 
+ (2.0028e-012) * a3 + ( - 2.6494e-012) * a4
parameters cgop=9.8713e-012 + (9.0834e-014) * a1 + (9.0737e-015) * a2 + (7.8719e-014) 
+ * a3 + ( - 1.3087e-013) * a4
parameters cglp=2.7408e-010 + (2.5220e-012) * a1 + (2.5194e-013) * a2 + (2.1857e-012) 
+ * a3 + ( - 3.6338e-012) * a4
parameters cfp=1.3500e-010 + (1.2422e-012) * a1 + (1.2409e-013) * a2 + (1.0766e-012) 
+ * a3 + ( - 1.7898e-012) * a4 + 3.57e-11 * ccoflag
parameters deta0n=0.0000e+000
parameters dpeta0n=0.0000e+000
parameters dpclmn=0.0000e+000
parameters dppclmn=0.0000e+000
parameters dpdiblc2n=0.0000e+000
parameters dlpdiblc2n=0.0000e+000
parameters dppdiblc2n=0.0000e+000
parameters dvoffn=0.0000e+000
parameters dpcitn=0.0000e+000
parameters dlu0n=0.0000e+000
parameters dpu0n=0.0000e+000
parameters dvsatn=0.0000e+000
parameters da0n=0.0000e+000
parameters dla0n=0.0000e+000
parameters dpa0n=0.0000e+000
parameters dlk2=0.0000e+000
parameters dlcn=3.7355e-010
parameters dwpdiblc2p=0.0000e+000
parameters dppdiblc2p=0.0000e+000
parameters dppclmp=0.0000e+000
parameters dpeta0p=0.0000e+000
parameters dlnfactorp=0.0000e+000
parameters dwk2p=0.0000e+000
parameters dpvoffp=0.0000e+000
parameters dpvsatp=0.0000e+000
parameters dlcp=2.4293e-011
parameters a1fn=1.250e+42
parameters a2fn=7.000e+23
parameters a3fn=6.080e+7
parameters b1fn=-2.734e+41
parameters b2fn=-1.338e+23
parameters b3fn=-1.01e+7
parameters c1fn=6.10e+41
parameters c2fn=3.20e+23
parameters c3fn=3.04e+7
parameters a1fp=1.345e+42
parameters a2fp=5.000e+23
parameters a3fp=8.5e+9
parameters b1fp=-1.623e+41
parameters b2fp=-1.175e+23
parameters b3fp=-2.19e+9
parameters c1fp=3.50e+41
parameters c2fp=3.60e+23
parameters c3fp=6.50e+9
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "cmn018_assp_v1d2.scs" section=mos
 
endsection mc
 
// *****************************   LIBRARY OF mote carlo CORNER CASE   *******************************

section mc_3v
include "cmn018_assp_v1d2.scs" section=setup_3v
parameters parn1_3v=0
parameters parn2_3v=0
parameters parp1_3v=0
parameters parp2_3v=0
parameters a1_3v=par6 * 5.2630e+000 * 3 / 2.1
parameters a2_3v=par7 * 2.1720e+000 * 3 / 2.1
parameters a3_3v=par8 * 2.0038e+000 * 3 / 2.1
parameters a4_3v=par9 * 1.2522e+000 * 3 / 2.1
parameters toxn_3v=6.7000e-009 + ( - 2.1396e-011) * a1_3v + (3.5960e-012) * a2_3v 
+ + (1.1194e-011) * a3_3v + ( - 7.5090e-012) * a4_3v
parameters dxln_3v=0.0000e+000 + ( - 1.2303e-009) * a1_3v + (2.0677e-010) * a2_3v 
+ + (6.4366e-010) * a3_3v + ( - 4.3177e-010) * a4_3v
parameters dxwn_3v=0.0000e+000 + (1.8103e-009) * a1_3v + ( - 2.7930e-009) * a2_3v 
+ + (4.1276e-009) * a3_3v + ( - 1.1986e-010) * a4_3v
parameters cjn_3v=8.9200e-004 + ( - 5.0504e-006) * a1_3v + (5.4750e-006) * a2_3v 
+ + ( - 2.9634e-006) * a3_3v + ( - 1.4531e-006) * a4_3v
parameters cjswn_3v=1.1400e-010 + ( - 1.3717e-012) * a1_3v + (1.4870e-012) * a2_3v 
+ + ( - 8.0487e-013) * a3_3v + ( - 3.9467e-013) * a4_3v
parameters cjswgn_3v=2.7100e-010 + ( - 3.0722e-012) * a1_3v + (3.3305e-012) * a2_3v 
+ + ( - 1.8026e-012) * a3_3v + ( - 8.8393e-013) * a4_3v
parameters cgon_3v=3.1796e-011 + (2.3811e-013) * a1_3v + ( - 4.0019e-014) * a2_3v 
+ + ( - 1.2457e-013) * a3_3v + (8.3564e-014) * a4_3v
parameters cgln_3v=1.8482e-010 + (1.3841e-012) * a1_3v + ( - 2.3263e-013) * a2_3v 
+ + ( - 7.2414e-013) * a3_3v + (4.8576e-013) * a4_3v
parameters dvthn_3v=0.0000e+000 + ( - 2.5522e-003) * a1_3v + (2.8003e-003) * a2_3v 
+ + ( - 1.5789e-003) * a3_3v + ( - 9.2087e-004) * a4_3v
parameters dlvthn_3v=0.0000e+000 + ( - 6.3303e-010) * a1_3v + (6.4599e-010) * a2_3v 
+ + ( - 2.7386e-010) * a3_3v + (4.1720e-011) * a4_3v
parameters dwvthn_3v=0.0000e+000 + ( - 2.8341e-010) * a1_3v + (3.0724e-010) * a2_3v 
+ + ( - 1.6630e-010) * a3_3v + ( - 8.1543e-011) * a4_3v
parameters dpvthn_3v=0.0000e+000 + ( - 1.3052e-016) * a1_3v + (1.4485e-016) * a2_3v 
+ + ( - 8.4717e-017) * a3_3v + ( - 5.6208e-017) * a4_3v
parameters du0n_3v=0.0000e+000 + (3.0397e-005) * a1_3v + ( - 2.8255e-005) * a2_3v 
+ + (6.4511e-006) * a3_3v + ( - 1.7371e-005) * a4_3v
parameters dvsatn_3v=0.0000e+000 + (3.2195e+001) * a1_3v + (5.3558e+000) * a2_3v 
+ + ( - 7.8692e+001) * a3_3v + ( - 2.1459e+002) * a4_3v
parameters dpvsatn_3v=0.0000e+000 + (3.1100e-011) * a1_3v + ( - 3.2037e-011) * a2_3v 
+ + (1.4182e-011) * a3_3v + ( - 3.7927e-013) * a4_3v
parameters dk2n_3v=0.0000e+000 + ( - 1.1337e-003) * a1_3v + (1.2289e-003) * a2_3v 
+ + ( - 6.6518e-004) * a3_3v + ( - 3.2617e-004) * a4_3v
parameters dpatn_3v=0.0000e+000 + (2.2068e-011) * a1_3v + ( - 1.0504e-011) * a2_3v 
+ + ( - 1.9579e-011) * a3_3v + ( - 6.8269e-011) * a4_3v
parameters cfn_3v=1.3600e-010 + (1.0163e-012) * a1_3v + ( - 1.7081e-013) * a2_3v 
+ + ( - 5.3172e-013) * a3_3v + (3.5668e-013) * a4_3v + 4.46e-11 * ccoflag_3v
parameters dlcitn_3v=0.0000e+000 + ( - 7.6445e-012) * a1_3v + ( - 2.2649e-011) * 
+ a2_3v + ( - 8.4658e-011) * a3_3v + (2.9001e-011) * a4_3v
parameters toxp_3v=6.7940e-009 + ( - 2.1396e-011) * a1_3v + (3.5960e-012) * a2_3v 
+ + (1.1194e-011) * a3_3v + ( - 7.5090e-012) * a4_3v
parameters dxlp_3v=0.0000e+000 + ( - 1.2303e-009) * a1_3v + (2.0677e-010) * a2_3v 
+ + (6.4366e-010) * a3_3v + ( - 4.3177e-010) * a4_3v
parameters dxwp_3v=0.0000e+000 + (1.8541e-009) * a1_3v + (4.2713e-009) * a2_3v + 
+ (1.7128e-009) * a3_3v + ( - 1.3664e-009) * a4_3v
parameters cjp_3v=1.0100e-003 + ( - 5.7753e-006) * a1_3v + ( - 6.5024e-006) * a2_3v 
+ + (9.9115e-007) * a3_3v + (5.9814e-007) * a4_3v
parameters cjswp_3v=1.2000e-010 + ( - 1.3792e-012) * a1_3v + ( - 1.5528e-012) * 
+ a2_3v + (2.3669e-013) * a3_3v + (1.4284e-013) * a4_3v
parameters cjswgp_3v=2.6000e-010 + ( - 2.9882e-012) * a1_3v + ( - 3.3644e-012) * 
+ a2_3v + (5.1283e-013) * a3_3v + (3.0949e-013) * a4_3v
parameters cgop_3v=5.2457e-012 + (3.9284e-014) * a1_3v + ( - 6.6023e-015) * a2_3v 
+ + ( - 2.0552e-014) * a3_3v + (1.3787e-014) * a4_3v
parameters cglp_3v=1.5361e-010 + (1.1504e-012) * a1_3v + ( - 1.9334e-013) * a2_3v 
+ + ( - 6.0185e-013) * a3_3v + (4.0372e-013) * a4_3v
parameters dvthp_3v=0.0000e+000 + (2.6434e-003) * a1_3v + (2.9762e-003) * a2_3v 
+ + ( - 4.5366e-004) * a3_3v + ( - 2.7378e-004) * a4_3v
parameters dlvthp_3v=0.0000e+000 + (7.2223e-010) * a1_3v + (7.4246e-010) * a2_3v 
+ + ( - 1.5553e-010) * a3_3v + ( - 2.0677e-010) * a4_3v
parameters dwvthp_3v=0.0000e+000 + (2.5285e-010) * a1_3v + (2.8468e-010) * a2_3v 
+ + ( - 4.3393e-011) * a3_3v + ( - 2.6187e-011) * a4_3v
parameters dpvthp_3v=0.0000e+000 + (7.5164e-017) * a1_3v + (1.0230e-016) * a2_3v 
+ + ( - 5.0039e-018) * a3_3v + (2.5207e-017) * a4_3v
parameters du0p_3v=0.0000e+000 + ( - 1.0480e-006) * a1_3v + ( - 6.1291e-006) * a2_3v 
+ + ( - 2.0309e-006) * a3_3v + ( - 9.1291e-006) * a4_3v
parameters dvsatp_3v=0.0000e+000 + ( - 4.4547e+002) * a1_3v + ( - 6.1645e+002) * 
+ a2_3v + (2.5129e+001) * a3_3v + ( - 1.6831e+002) * a4_3v
parameters dpvsatp_3v=0.0000e+000 + (7.9534e-011) * a1_3v + (5.4197e-011) * a2_3v 
+ + ( - 2.9441e-011) * a3_3v + ( - 7.4220e-011) * a4_3v
parameters dk2p_3v=0.0000e+000 + ( - 1.1493e-003) * a1_3v + ( - 1.2940e-003) * a2_3v 
+ + (1.9724e-004) * a3_3v + (1.1903e-004) * a4_3v
parameters dlcitp_3v=0.0000e+000 + ( - 5.9723e-012) * a1_3v + ( - 1.7695e-011) * 
+ a2_3v + ( - 6.6139e-011) * a3_3v + (2.2657e-011) * a4_3v
parameters dpcitp_3v=0.0000e+000 + ( - 2.3889e-019) * a1_3v + ( - 7.0779e-019) * 
+ a2_3v + ( - 2.6456e-018) * a3_3v + (9.0627e-019) * a4_3v
parameters cfp_3v=1.3500e-010 + (1.0110e-012) * a1_3v + ( - 1.6991e-013) * a2_3v 
+ + ( - 5.2892e-013) * a3_3v + (3.5480e-013) * a4_3v + 4.29e-11 * ccoflag_3v
parameters dlcn_3v=4.2248e-008
parameters dpcitn_3v=0.0000e+000
parameters dlcp_3v=2.7020e-008
parameters a1fn_3v=3.410e+42
parameters a2fn_3v=2.100e+23
parameters a3fn_3v=1.350e+6
parameters b1fn_3v=-5.230e+41
parameters b2fn_3v=-8.495e+22
parameters b3fn_3v=-5.425e+5
parameters c1fn_3v=1.30e+42
parameters c2fn_3v=2.13e+23
parameters c3fn_3v=1.52e+6
parameters a1fp_3v=1.860e+42
parameters a2fp_3v=4.750e+23
parameters a3fp_3v=1.150e+10
parameters b1fp_3v=-1.939e+41
parameters b2fp_3v=-1.298e+23
parameters b3fp_3v=-3.805e+9
parameters c1fp_3v=4.30e+41
parameters c2fp_3v=3.00e+23
parameters c3fp_3v=8.70e+9
parameters noian_3v=a1fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b1fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c1fn_3v
parameters noibn_3v=a2fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b2fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c2fn_3v
parameters noicn_3v=a3fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b3fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c3fn_3v
parameters noiap_3v=a1fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b1fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c1fp_3v
parameters noibp_3v=a2fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b2fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c2fp_3v
parameters noicp_3v=a3fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b3fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c3fp_3v
include "cmn018_assp_v1d2.scs" section=mos_3v
 
endsection mc_3v
 
// *****************************   LIBRARY OF MC CORNER CASE   *******************************

section mc_m
include "cmn018_assp_v1d2.scs" section=setup_m
parameters parn1m=0
parameters parn2m=0
parameters parp1m=0
parameters parp2m=0
parameters a1_m=par1 * 6.3577e+000 * 3 / 2.1
parameters a2_m=par2 * 2.4564e+000 * 3 / 2.1
parameters a3_m=par3 * 2.0804e+000 * 3 / 2.1
parameters a4_m=par4 * 1.1033e+000 * 3 / 2.1
parameters toxnm=3.9810e-009 + (7.8963e-012) * a1_m + (4.1639e-012) * a2_m + ( - 
+ 1.9133e-011) * a3_m + ( - 6.8681e-012) * a4_m
parameters dxlnm=0.0000e+000 + (9.9299e-010) * a1_m + (8.7187e-010) * a2_m + ( - 
+ 1.2941e-009) * a3_m + ( - 1.6747e-009) * a4_m
parameters dxwnm=0.0000e+000 + ( - 7.3272e-010) * a1_m + ( - 2.7512e-009) * a2_m 
+ + (4.9050e-009) * a3_m + (4.4859e-009) * a4_m
parameters dvthnm=0.0000e+000 + (3.5549e-003) * a1_m + ( - 9.0757e-004) * a2_m + 
+ (8.1254e-004) * a3_m + (5.4383e-004) * a4_m
parameters dlvthnm=0.0000e+000 + (7.7120e-010) * a1_m + ( - 3.0719e-010) * a2_m 
+ + (1.7114e-010) * a3_m + (6.2472e-011) * a4_m
parameters dwvthnm=0.0000e+000 + (3.9392e-010) * a1_m + (2.1991e-011) * a2_m + (9.5742e-011) 
+ * a3_m + (1.2193e-010) * a4_m
parameters dpvthnm=0.0000e+000 + (9.4798e-017) * a1_m + ( - 2.4202e-017) * a2_m 
+ + (2.1668e-017) * a3_m + (1.4502e-017) * a4_m
parameters dleta0nm=0.0000e+000 + (4.7399e-010) * a1_m + ( - 1.2101e-010) * a2_m 
+ + (1.0834e-010) * a3_m + (7.2511e-011) * a4_m
parameters dlpclmnm=0.0000e+000 + ( - 2.3699e-009) * a1_m + (6.0505e-010) * a2_m 
+ + ( - 5.4169e-010) * a3_m + ( - 3.6255e-010) * a4_m
parameters dlvoffnm=0.0000e+000 + ( - 6.4886e-010) * a1_m + (2.8821e-010) * a2_m 
+ + ( - 1.4260e-010) * a3_m + ( - 3.7589e-011) * a4_m
parameters dpvoffnm=0.0000e+000 + ( - 5.7647e-017) * a1_m + (1.2266e-017) * a2_m 
+ + ( - 1.3290e-017) * a3_m + ( - 1.0052e-017) * a4_m
parameters dcitnm=0.0000e+000 + ( - 2.3699e-005) * a1_m + (6.0505e-006) * a2_m + 
+ ( - 5.4169e-006) * a3_m + ( - 3.6255e-006) * a4_m
parameters dlcitnm=0.0000e+000 + (1.0665e-011) * a1_m + ( - 2.7227e-012) * a2_m 
+ + (2.4376e-012) * a3_m + (1.6315e-012) * a4_m
parameters dpcitnm=0.0000e+000 + ( - 8.7594e-019) * a1_m + (1.0203e-018) * a2_m 
+ + ( - 1.6313e-019) * a3_m + (2.6687e-019) * a4_m
parameters du0nm=0.0000e+000 + (5.9249e-005) * a1_m + ( - 1.5126e-005) * a2_m + 
+ (1.3542e-005) * a3_m + (9.0639e-006) * a4_m
parameters dlu0nm=0.0000e+000 + ( - 5.5245e-011) * a1_m + (7.9762e-012) * a2_m + 
+ ( - 1.2913e-011) * a3_m + ( - 1.1535e-011) * a4_m
parameters dlvsatnm=0.0000e+000 + (7.3020e-005) * a1_m + ( - 1.2514e-005) * a2_m 
+ + (1.6975e-005) * a3_m + (1.4254e-005) * a4_m
parameters dpvsatnm=0.0000e+000 + (4.8390e-011) * a1_m + (5.5054e-011) * a2_m + 
+ (1.4198e-011) * a3_m + (4.1323e-011) * a4_m
parameters dpa0nm=0.0000e+000 + (9.4798e-015) * a1_m + ( - 2.4202e-015) * a2_m + 
+ (2.1668e-015) * a3_m + (1.4502e-015) * a4_m
parameters dk2m=0.0000e+000 + (1.1850e-003) * a1_m + ( - 3.0252e-004) * a2_m + (2.7085e-004) 
+ * a3_m + (1.8128e-004) * a4_m
parameters cjnm=9.1300e-004 + (7.5829e-006) * a1_m + ( - 1.9336e-006) * a2_m + (1.7332e-006) 
+ * a3_m + (1.1557e-006) * a4_m
parameters cjswnm=1.0400e-010 + ( - 6.6189e-011) * a1_m + (1.1948e-010) * a2_m + 
+ ( - 1.0353e-011) * a3_m + (4.1495e-011) * a4_m
parameters cjswgnm=3.4900e-010 + (2.8475e-012) * a1_m + ( - 7.3657e-013) * a2_m 
+ + (6.5108e-013) * a3_m + (4.5317e-013) * a4_m
parameters cgonm=2.0870e-010 + ( - 1.4413e-012) * a1_m + ( - 7.5948e-013) * a2_m 
+ + (3.4940e-012) * a3_m + (1.2523e-012) * a4_m
parameters cglnm=3.9670e-012 + ( - 2.7394e-014) * a1_m + ( - 1.4371e-014) * a2_m 
+ + (6.6423e-014) * a3_m + (2.3971e-014) * a4_m
parameters cfnm=1.3500e-010 + ( - 9.3261e-013) * a1_m + ( - 4.8556e-013) * a2_m 
+ + (2.2608e-012) * a3_m + (8.2831e-013) * a4_m + 3.6e-11 * ccoflag_m
parameters toxpm=4.0600e-009 + (7.8963e-012) * a1_m + (4.1639e-012) * a2_m + ( - 
+ 1.9133e-011) * a3_m + ( - 6.8681e-012) * a4_m
parameters dxlpm=0.0000e+000 + (9.9299e-010) * a1_m + (8.7187e-010) * a2_m + ( - 
+ 1.2941e-009) * a3_m + ( - 1.6747e-009) * a4_m
parameters dxwpm=0.0000e+000 + ( - 2.0310e-009) * a1_m + (1.2939e-009) * a2_m + 
+ (1.7915e-009) * a3_m + ( - 2.0821e-009) * a4_m
parameters dvthpm=0.0000e+000 + ( - 3.3179e-003) * a1_m + (8.4707e-004) * a2_m + 
+ ( - 7.5837e-004) * a3_m + ( - 5.0758e-004) * a4_m
parameters dlvthpm=0.0000e+000 + ( - 9.0163e-010) * a1_m + (1.8903e-010) * a2_m 
+ + ( - 2.0800e-010) * a3_m + ( - 1.5864e-010) * a4_m
parameters dwvthpm=0.0000e+000 + ( - 1.1078e-009) * a1_m + (4.9117e-010) * a2_m 
+ + ( - 2.4351e-010) * a3_m + ( - 6.4627e-011) * a4_m
parameters dpdiblc2pm=0.0000e+000 + ( - 7.8462e-005) * a1_m + ( - 4.1248e-005) * 
+ a2_m + ( - 2.0787e-005) * a3_m + ( - 4.2840e-005) * a4_m
parameters dlpdiblc2pm=0.0000e+000 + ( - 8.0069e-013) * a1_m + (1.4300e-012) * a2_m 
+ + ( - 1.2596e-013) * a3_m + (4.9424e-013) * a4_m
parameters dwpdiblc2pm=0.0000e+000 + ( - 8.0069e-012) * a1_m + (1.4300e-011) * a2_m 
+ + ( - 1.2596e-012) * a3_m + (4.9424e-012) * a4_m
parameters ori_dppdiblc2pm=0.0000e+000 + (1.9214e-017) * a1_m + (5.6374e-017) * 
+ a2_m + (7.2442e-018) * a3_m + (3.3776e-017) * a4_m
parameters dppdiblc2pm=((ori_dppdiblc2pm + 1e-20) + sqrt((ori_dppdiblc2pm + 1e-20) 
+ * (ori_dppdiblc2pm + 1e-20) + 1e-50) - 1e-20 - sqrt(1e-20 * 1e-20 + 1e-50)) * 
+ 0.5
parameters dlpclmpm=0.0000e+000 + ( - 3.8428e-010) * a1_m + ( - 1.1275e-009) * a2_m 
+ + ( - 1.4488e-010) * a3_m + ( - 6.7552e-010) * a4_m
parameters dwpclmpm=0.0000e+000 + ( - 1.9214e-009) * a1_m + ( - 5.6374e-009) * a2_m 
+ + ( - 7.2442e-010) * a3_m + ( - 3.3776e-009) * a4_m
parameters dk2pm=0.0000e+000 + (1.5191e-003) * a1_m + ( - 3.8784e-004) * a2_m + 
+ (3.4723e-004) * a3_m + (2.3240e-004) * a4_m
parameters dvoffpm=0.0000e+000 + ( - 4.6767e-004) * a1_m + ( - 1.8313e-004) * a2_m 
+ + ( - 1.2098e-004) * a3_m + ( - 2.2378e-004) * a4_m
parameters dlvoffpm=0.0000e+000 + ( - 3.3805e-010) * a1_m + (4.5398e-010) * a2_m 
+ + ( - 6.0152e-011) * a3_m + (1.3330e-010) * a4_m
parameters dwvoffpm=0.0000e+000 + ( - 2.2578e-010) * a1_m + ( - 1.8748e-010) * a2_m 
+ + ( - 6.3017e-011) * a3_m + ( - 1.5789e-010) * a4_m
parameters dagspm=0.0000e+000 + (1.9696e-003) * a1_m + (1.0996e-004) * a2_m + (4.7871e-004) 
+ * a3_m + (6.0967e-004) * a4_m
parameters dlvsatpm=0.0000e+000 + ( - 8.0859e-005) * a1_m + ( - 2.1835e-004) * a2_m 
+ + ( - 2.9607e-005) * a3_m + ( - 1.3263e-004) * a4_m
parameters dwvsatpm=0.0000e+000 + (6.8059e-004) * a1_m + ( - 1.2155e-003) * a2_m 
+ + (1.0707e-004) * a3_m + ( - 4.2010e-004) * a4_m
parameters ori_dpvsatpm=0.0000e+000 + (1.7292e-009) * a1_m + (5.0737e-009) * a2_m 
+ + (6.5198e-010) * a3_m + (3.0398e-009) * a4_m
parameters dpvsatpm=((ori_dpvsatpm) + sqrt((ori_dpvsatpm) * (ori_dpvsatpm) + 1e-26) 
+ - sqrt(1e-26)) * 0.5
parameters cjpm=1.0500e-003 + (8.2717e-006) * a1_m + ( - 2.0774e-006) * a2_m + (1.8924e-006) 
+ * a3_m + (1.2882e-006) * a4_m
parameters cjswpm=1.2600e-010 + (1.0195e-012) * a1_m + ( - 2.6147e-013) * a2_m + 
+ (2.3306e-013) * a3_m + (1.5813e-013) * a4_m
parameters cjswgpm=3.5000e-010 + (2.9032e-012) * a1_m + ( - 7.4118e-013) * a2_m 
+ + (6.6357e-013) * a3_m + (4.4413e-013) * a4_m
parameters cgopm=2.6810e-011 + (9.2719e-014) * a1_m + (2.7642e-013) * a2_m + (5.0182e-013) 
+ * a3_m + ( - 6.1049e-013) * a4_m
parameters cglpm=2.3640e-010 + (8.1186e-013) * a1_m + (2.4296e-012) * a2_m + (4.4238e-012) 
+ * a3_m + ( - 5.3672e-012) * a4_m
parameters cfpm=1.3500e-010 + (4.6580e-013) * a1_m + (1.3965e-012) * a2_m + (2.5274e-012) 
+ * a3_m + ( - 3.0536e-012) * a4_m + 3.57e-11 * ccoflag_m
parameters deta0nm=0.0000e+000
parameters dpeta0nm=0.0000e+000
parameters dpclmnm=0.0000e+000
parameters dppclmnm=0.0000e+000
parameters dpdiblc2nm=0.0000e+000
parameters dlpdiblc2nm=0.0000e+000
parameters dppdiblc2nm=0.0000e+000
parameters dvoffnm=0.0000e+000
parameters dpu0nm=0.0000e+000
parameters dvsatnm=0.0000e+000
parameters da0nm=0.0000e+000
parameters dla0nm=0.0000e+000
parameters dlk2m=0.0000e+000
parameters dlcnm=1.9980e-008
parameters dpvthpm=0.0000e+000
parameters dppclmpm=0.0000e+000
parameters deta0pm=0.0000e+000
parameters dleta0pm=0.0000e+000
parameters dweta0pm=0.0000e+000
parameters dpeta0pm=0.0000e+000
parameters dcitpm=0.0000e+000
parameters dlcitpm=0.0000e+000
parameters dwcitpm=0.0000e+000
parameters dpcitpm=0.0000e+000
parameters dlnfactorpm=0.0000e+000
parameters duapm=0.0000e+000
parameters dluapm=0.0000e+000
parameters dwuapm=0.0000e+000
parameters dpuapm=0.0000e+000
parameters dlk2pm=0.0000e+000
parameters dwk2pm=0.0000e+000
parameters dpk2pm=0.0000e+000
parameters dpvoffpm=0.0000e+000
parameters dlcpm=2.7390e-008
parameters a1fn_m=7.000e+41
parameters a2fn_m=2.940e+24
parameters a3fn_m=2.200e+8
parameters b1fn_m=-1.450e+41
parameters b2fn_m=-1.250e+24
parameters b3fn_m=-8.780e+7
parameters c1fn_m=3.30e+41
parameters c2fn_m=3.60e+24
parameters c3fn_m=2.14e+8
parameters a1fp_m=9.000e+41
parameters a2fp_m=2.500e+24
parameters a3fp_m=3.500e+9
parameters b1fp_m=-1.486e+41
parameters b2fp_m=-4.265e+23
parameters b3fp_m=-1.769e+9
parameters c1fp_m=3.520e+41
parameters c2fp_m=1.280e+24
parameters c3fp_m=4.320e+9
parameters noian_m=a1fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b1fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c1fn_m
parameters noibn_m=a2fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b2fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c2fn_m
parameters noicn_m=a3fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b3fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c3fn_m
parameters noiap_m=a1fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b1fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c1fp_m
parameters noibp_m=a2fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b2fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c2fp_m
parameters noicp_m=a3fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b3fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c3fp_m
include "cmn018_assp_v1d2.scs" section=mos_m
 
endsection mc_m
 
// *****************************   LIBRARY OF MC CORNER CASE   *******************************

section mc_3m
include "cmn018_assp_v1d2.scs" section=setup_3m
parameters parn1_3m=0
parameters parn2_3m=0
parameters a1_3m=par6 * 3.9050e+000 * 3 / 2.1
parameters a2_3m=par7 * 1.5800e+000 * 3 / 2.1
parameters a3_3m=par8 * 9.8811e-001 * 3 / 2.1
parameters a4_3m=par9 * 5.2780e-001 * 3 / 2.1
parameters toxn_3m=6.7000e-009 + ( - 2.2553e-011) * a1_3m + ( - 4.0490e-011) * a2_3m 
+ + ( - 3.4956e-011) * a3_3m + (3.2353e-011) * a4_3m
parameters dxln_3m=0.0000e+000 + ( - 1.2968e-009) * a1_3m + ( - 2.3281e-009) * a2_3m 
+ + ( - 2.0100e-009) * a3_3m + (1.8603e-009) * a4_3m
parameters dxwn_3m=0.0000e+000 + (3.4519e-009) * a1_3m + ( - 2.3377e-009) * a2_3m 
+ + ( - 1.1042e-010) * a3_3m + (1.5236e-009) * a4_3m
parameters cjn_3m=8.7200e-004 + ( - 8.8133e-006) * a1_3m + (2.5978e-007) * a2_3m 
+ + (2.3036e-006) * a3_3m + ( - 2.8919e-006) * a4_3m
parameters cjswn_3m=1.2200e-010 + ( - 2.3907e-012) * a1_3m + (7.0470e-014) * a2_3m 
+ + (6.2488e-013) * a3_3m + ( - 7.8447e-013) * a4_3m
parameters cjswgn_3m=2.4400e-010 + ( - 4.9436e-012) * a1_3m + (1.4572e-013) * a2_3m 
+ + (1.2921e-012) * a3_3m + ( - 1.6221e-012) * a4_3m
parameters cgon_3m=2.0272e-011 + (2.8752e-013) * a1_3m + ( - 8.4749e-015) * a2_3m 
+ + ( - 7.5150e-014) * a3_3m + (9.4343e-014) * a4_3m
parameters cgln_3m=3.1065e-010 + (4.4058e-012) * a1_3m + ( - 1.2999e-013) * a2_3m 
+ + ( - 1.1517e-012) * a3_3m + (1.4453e-012) * a4_3m
parameters dvthn_3m=0.0000e+000 + ( - 5.2677e-003) * a1_3m + (1.5527e-004) * a2_3m 
+ + (1.3769e-003) * a3_3m + ( - 1.7285e-003) * a4_3m
parameters dlvthn_3m=0.0000e+000 + ( - 2.2562e-009) * a1_3m + (5.7304e-012) * a2_3m 
+ + (5.0214e-010) * a3_3m + ( - 9.0970e-010) * a4_3m
parameters dwvthn_3m=0.0000e+000 + ( - 5.6730e-010) * a1_3m + (1.6722e-011) * a2_3m 
+ + (1.4828e-010) * a3_3m + ( - 1.8615e-010) * a4_3m
parameters dpvthn_3m=0.0000e+000 + ( - 1.9897e-016) * a1_3m + (3.6252e-017) * a2_3m 
+ + (9.5792e-017) * a3_3m + (1.9400e-017) * a4_3m
parameters du0n_3m=0.0000e+000 + (1.0441e-004) * a1_3m + (1.2724e-005) * a2_3m + 
+ ( - 4.5211e-006) * a3_3m + (7.8298e-005) * a4_3m
parameters dvsatn_3m=0.0000e+000 + ( - 3.7866e+001) * a1_3m + (7.4044e+001) * a2_3m 
+ + (1.1499e+002) * a3_3m + (1.9082e+002) * a4_3m
parameters dpvsatn_3m=0.0000e+000 + (1.1731e-010) * a1_3m + (5.0503e-012) * a2_3m 
+ + ( - 1.8403e-011) * a3_3m + (6.2207e-011) * a4_3m
parameters dk2n_3m=0.0000e+000 + ( - 2.0261e-003) * a1_3m + (5.9720e-005) * a2_3m 
+ + (5.2956e-004) * a3_3m + ( - 6.6481e-004) * a4_3m
parameters dlcitn_3m=0.0000e+000 + ( - 2.8666e-011) * a1_3m + (1.4521e-010) * a2_3m 
+ + ( - 1.3600e-010) * a3_3m + (1.9620e-011) * a4_3m
parameters dpcitn_3m=0.0000e+000 + ( - 1.7200e-018) * a1_3m + (8.7123e-018) * a2_3m 
+ + ( - 8.1602e-018) * a3_3m + (1.1772e-018) * a4_3m
parameters cfn_3m=1.3600e-010 + (1.0735e-012) * a1_3m + (1.9273e-012) * a2_3m + 
+ (1.6639e-012) * a3_3m + ( - 1.5400e-012) * a4_3m + 4.46e-11 * ccoflag_3m
parameters dlcn_3m=6.3814e-008
parameters a1fn_3m=3.245e+42
parameters a2fn_3m=1.415e+24
parameters a3fn_3m=5.280e+7
parameters b1fn_3m=-9.975e+41
parameters b2fn_3m=-4.220e+23
parameters b3fn_3m=-3.385e+7
parameters c1fn_3m=2.12e+42
parameters c2fn_3m=1.28e+24
parameters c3fn_3m=8.32e+7
parameters noian_3m=a1fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b1fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c1fn_3m
parameters noibn_3m=a2fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b2fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c2fn_3m
parameters noicn_3m=a3fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b3fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c3fn_3m
include "cmn018_assp_v1d2.scs" section=mos_3m
 
endsection mc_3m
 
// *****************************   LIBRARY OF MC CORNER CASE   *******************************

section mc_na
include "cmn018_assp_v1d2.scs" section=setup_na
parameters parn1_na=0
parameters parn2_na=0
parameters a1_na=par1 * 3.7397e+000 * 3 / 2.1
parameters a2_na=par2 * 1.5701e+000 * 3 / 2.1
parameters a3_na=par3 * 1.1264e+000 * 3 / 2.1
parameters a4_na=par4 * 5.3018e-001 * 3 / 2.1
parameters toxn_na=3.9860e-009 + ( - 2.7522e-011) * a1_na + ( - 2.2201e-011) * a2_na 
+ + ( - 3.3846e-011) * a3_na + (1.5997e-011) * a4_na
parameters dxln_na=0.0000e+000 + ( - 1.5825e-009) * a1_na + ( - 1.2766e-009) * a2_na 
+ + ( - 1.9461e-009) * a3_na + (9.1984e-010) * a4_na
parameters dxwn_na=0.0000e+000 + (3.1768e-009) * a1_na + ( - 4.6810e-009) * a2_na 
+ + ( - 8.0487e-010) * a3_na + ( - 3.0200e-010) * a4_na
parameters dvth0n_na=0.0000e+000 + ( - 1.3571e-002) * a1_na + (3.2092e-003) * a2_na 
+ + (9.4864e-003) * a3_na + (2.1346e-003) * a4_na
parameters dlvth0n_na=0.0000e+000 + ( - 7.4321e-010) * a1_na + (2.1729e-010) * a2_na 
+ + (5.9865e-010) * a3_na + (3.4404e-010) * a4_na
parameters dwvth0n_na=0.0000e+000 + ( - 4.3160e-010) * a1_na + (1.4270e-010) * a2_na 
+ + (3.7911e-010) * a3_na + (2.9008e-010) * a4_na
parameters du0n_na=0.0000e+000 + ( - 7.9792e-004) * a1_na + (1.5949e-004) * a2_na 
+ + (5.0215e-004) * a3_na + ( - 3.4109e-005) * a4_na
parameters dlu0n_na=0.0000e+000 + (9.0200e-011) * a1_na + (3.9063e-011) * a2_na 
+ + (5.1993e-011) * a3_na + (3.1601e-010) * a4_na
parameters dpu0n_na=0.0000e+000 + (7.2121e-017) * a1_na + (6.3677e-018) * a2_na 
+ + ( - 5.7956e-018) * a3_na + (1.1672e-016) * a4_na
parameters dwk2n_na=0.0000e+000 + ( - 2.9213e-010) * a1_na + (6.9928e-011) * a2_na 
+ + (2.0582e-010) * a3_na + (5.0585e-011) * a4_na
parameters dlvoffn_na=0.0000e+000 + (4.7666e-010) * a1_na + ( - 6.6222e-009) * a2_na 
+ + (4.1688e-009) * a3_na + (1.5625e-011) * a4_na
parameters dpvoffn_na=0.0000e+000 + (7.1499e-017) * a1_na + ( - 9.9334e-016) * a2_na 
+ + (6.2533e-016) * a3_na + (2.3438e-018) * a4_na
parameters cjn_na=9.8100e-004 + ( - 9.5657e-006) * a1_na + (2.2897e-006) * a2_na 
+ + (6.7393e-006) * a3_na + (1.6564e-006) * a4_na
parameters cjswn_na=1.1850e-010 + ( - 2.2722e-012) * a1_na + (5.4386e-013) * a2_na 
+ + (1.6008e-012) * a3_na + (3.9346e-013) * a4_na
parameters cjswgn_na=3.8267e-010 + ( - 7.4526e-012) * a1_na + (1.7839e-012) * a2_na 
+ + (5.2506e-012) * a3_na + (1.2905e-012) * a4_na
parameters cgon_na=7.5086e-012 + (7.2327e-014) * a1_na + (5.8344e-014) * a2_na + 
+ (8.8947e-014) * a3_na + ( - 4.2041e-014) * a4_na
parameters cgln_na=8.6913e-010 + (8.3720e-012) * a1_na + (6.7534e-012) * a2_na + 
+ (1.0296e-011) * a3_na + ( - 4.8663e-012) * a4_na
parameters cfn_na=1.3500e-010 + (1.3001e-012) * a1_na + (1.0484e-012) * a2_na + 
+ (1.5977e-012) * a3_na + ( - 8.0169e-013) * a4_na + 3.57e-11 * ccoflag_na
parameters dk2n_na=0.0000e+000
parameters dlcn_na=1.0128e-007
parameters a1fn_na=4.529e+42
parameters a2fn_na=3.500e+23
parameters a3fn_na=1.510e+6
parameters b1fn_na=-6.730e+41
parameters b2fn_na=-1.535e+23
parameters b3fn_na=-5.855e+7
parameters c1fn_na=1.542e+42
parameters c2fn_na=4.400e+23
parameters c3fn_na=1.600e+6
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "cmn018_assp_v1d2.scs" section=mos_na
 
endsection mc_na
 
// *****************************   LIBRARY OF MC CORNER CASE   *******************************

section mc_3vna
include "cmn018_assp_v1d2.scs" section=setup_3vna
parameters parn1_3vna=0
parameters parn2_3vna=0
parameters a1_3vna=par6 * 3.9916e+000 * 3 / 2.1
parameters a2_3vna=par7 * 1.3002e+000 * 3 / 2.1
parameters a3_3vna=par8 * 1.1525e+000 * 3 / 2.1
parameters toxn_3vna=6.6930e-009 + ( - 2.4742e-011) * a1_3vna + ( - 3.4676e-011) 
+ * a2_3vna + ( - 3.4097e-011) * a3_3vna
parameters dxln_3vna=0.0000e+000 + ( - 1.7373e-009) * a1_3vna + (2.3316e-009) * 
+ a2_3vna + ( - 4.8220e-009) * a3_3vna
parameters dxwn_3vna=0.0000e+000 + (3.0915e-009) * a1_3vna + ( - 5.0795e-009) * 
+ a2_3vna + (2.7048e-010) * a3_3vna
parameters cjn_3vna=8.9200e-004 + ( - 8.2410e-006) * a1_3vna + (1.3323e-006) * a2_3vna 
+ + (4.4434e-006) * a3_3vna
parameters cjswn_3vna=1.1400e-010 + ( - 2.2383e-012) * a1_3vna + (3.6186e-013) * 
+ a2_3vna + (1.2069e-012) * a3_3vna
parameters cjswgn_3vna=2.7100e-010 + ( - 5.0130e-012) * a1_3vna + (8.1044e-013) 
+ * a2_3vna + (2.7030e-012) * a3_3vna
parameters cgon_3vna=1.8406e-010 + (1.5939e-012) * a1_3vna + (2.2338e-012) * a2_3vna 
+ + (2.1965e-012) * a3_3vna
parameters cgln_3vna=1.5160e-010 + (1.3128e-012) * a1_3vna + (1.8399e-012) * a2_3vna 
+ + (1.8092e-012) * a3_3vna
parameters dvthn_3vna=0.0000e+000 + ( - 8.0767e-003) * a1_3vna + (1.4044e-003) * 
+ a2_3vna + (4.4740e-003) * a3_3vna
parameters dlvthn_3vna=0.0000e+000 + ( - 2.6210e-009) * a1_3vna + (3.7438e-010) 
+ * a2_3vna + (1.3537e-009) * a3_3vna
parameters dwvthn_3vna=0.0000e+000 + ( - 8.4467e-010) * a1_3vna + (1.4643e-010) 
+ * a2_3vna + (4.6735e-010) * a3_3vna
parameters dpvthn_3vna=0.0000e+000 + (1.1125e-016) * a1_3vna + (1.1624e-017) * a2_3vna 
+ + ( - 2.4254e-017) * a3_3vna
parameters du0n_3vna=0.0000e+000 + (5.5821e-004) * a1_3vna + ( - 7.0504e-005) * 
+ a2_3vna + ( - 2.7716e-004) * a3_3vna
parameters dlu0n_3vna=0.0000e+000 + ( - 2.4009e-010) * a1_3vna + (8.3229e-011) * 
+ a2_3vna + (1.8305e-010) * a3_3vna
parameters dpu0n_3vna=0.0000e+000 + (1.9267e-016) * a1_3vna + (1.4224e-018) * a2_3vna 
+ + ( - 6.4581e-017) * a3_3vna
parameters dk2n_3vna=0.0000e+000 + ( - 5.5495e-004) * a1_3vna + (8.9717e-005) * 
+ a2_3vna + (2.9922e-004) * a3_3vna
parameters dwk2n_3vna=0.0000e+000 + ( - 2.8487e-010) * a1_3vna + (4.6055e-011) * 
+ a2_3vna + (1.5360e-010) * a3_3vna
parameters dlvoffn_3vna=0.0000e+000 + (1.3680e-009) * a1_3vna + ( - 1.8806e-008) 
+ * a2_3vna + (1.2441e-008) * a3_3vna
parameters cfn_3vna=1.3600e-010 + (1.1753e-012) * a1_3vna + (1.6471e-012) * a2_3vna 
+ + (1.6196e-012) * a3_3vna + 4.46e-11 * ccoflag_3vna
parameters dlcn_3vna=6.5564e-008
parameters dpvoffn_3vna=0.0000e+000
parameters a1fn_3vna=1.750e+41
parameters a2fn_3vna=1.115e+23
parameters a3fn_3vna=1.930e+8
parameters b1fn_3vna=-4.144e+40
parameters b2fn_3vna=-4.365e+22
parameters b3fn_3vna=-7.790e+7
parameters c1fn_3vna=9.230e+40
parameters c2fn_3vna=1.280e+23
parameters c3fn_3vna=2.320e+8
parameters noian_3vna=a1fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b1fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c1fn_3vna
parameters noibn_3vna=a2fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b2fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c2fn_3vna
parameters noicn_3vna=a3fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b3fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c3fn_3vna
include "cmn018_assp_v1d2.scs" section=mos_3vna
 
endsection mc_3vna
 
// **************************************************************             
+                                                                              
+                                                                              
+                                                                              
+                                                                              
+                                                                              
//                                                      
//                                                              *             
+                                                                              
+                                                                              
+                                                                              
+                                                                              
+                                                                              
//                                                      
//                 1.8V NORMAL DEVICES LIB                      *             
+                                                                              
+                                                                              
+                                                                              
+                                                                              
//                      
//                                                              *             
+                                                                              
//                                                                 
// ************************************************************** 
// *****************************     LIBRARY OF TYPICAL CASE     *******************************

section tt
include "cmn018_assp_v1d2.scs" section=setup
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters toxn=3.981e-09
parameters dxln=0
parameters dxwn=0
parameters dvthn=0
parameters dlvthn=0
parameters dwvthn=0
parameters dpvthn=0
parameters deta0n=0
parameters dleta0n=0
parameters dpeta0n=0
parameters dpclmn=0
parameters dlpclmn=0
parameters dppclmn=0
parameters dpdiblc2n=0
parameters dlpdiblc2n=0
parameters dppdiblc2n=0
parameters dvoffn=0
parameters dlvoffn=0
parameters dpvoffn=0
parameters dcitn=0
parameters dlcitn=0
parameters dpcitn=0
parameters du0n=0
parameters dlu0n=0
parameters dpu0n=0
parameters dvsatn=0
parameters dlvsatn=0
parameters dpvsatn=0
parameters da0n=0
parameters dla0n=0
parameters dpa0n=0
parameters cjn=0.000981
parameters cjswn=1.185e-10
parameters cjswgn=3.82e-10
parameters dk2=0
parameters dlk2=0
parameters cgon=9.54839e-11
parameters cgln=1.29912e-10
parameters dlcn=3.73547e-10
parameters cfn=1.35e-10 + 3.57e-11 * ccoflag
parameters toxp=4.06e-09
parameters dxlp=0
parameters dxwp=0
parameters dvthp=0
parameters dlvthp=0
parameters dwvthp=0
parameters dlpdiblc2p=0
parameters dwpdiblc2p=0
parameters dppdiblc2p=0
parameters dlpclmp=0
parameters dwpclmp=0
parameters dppclmp=0
parameters dleta0p=0
parameters dweta0p=0
parameters dpeta0p=0
parameters dlcitp=0
parameters dwcitp=0
parameters dpcitp=0
parameters dlnfactorp=0
parameters du0p=0
parameters dlu0p=0
parameters dwu0p=0
parameters dwk2p=0
parameters dvoffp=0
parameters dlvoffp=0
parameters dwvoffp=0
parameters dpvoffp=0
parameters dagsp=0
parameters dlvsatp=0
parameters dwvsatp=0
parameters dpvsatp=0
parameters dk2p=0
parameters dlk2p=0
parameters cjp=0.00112
parameters cjswp=1.345e-10
parameters cjswgp=4.36e-10
parameters dlcp=2.42932e-11
parameters cgop=9.87133e-12
parameters cglp=2.74083e-10
parameters cfp=1.35e-10 + 3.57e-11 * ccoflag
parameters a1fn=1.250e+42
parameters a2fn=7.000e+23
parameters a3fn=6.080e+7
parameters b1fn=-2.734e+41
parameters b2fn=-1.338e+23
parameters b3fn=-1.01e+7
parameters c1fn=6.10e+41
parameters c2fn=3.20e+23
parameters c3fn=3.04e+7
parameters a1fp=1.345e+42
parameters a2fp=5.000e+23
parameters a3fp=8.5e+9
parameters b1fp=-1.623e+41
parameters b2fp=-1.175e+23
parameters b3fp=-2.19e+9
parameters c1fp=3.50e+41
parameters c2fp=3.60e+23
parameters c3fp=6.50e+9
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "cmn018_assp_v1d2.scs" section=mos
 
endsection tt
 
// *****************************   LIBRARY OF SNSP CORNER CASE   *******************************

section ss
include "cmn018_assp_v1d2.scs" section=setup
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters toxn=4.061e-09
parameters dxln=1.15e-08
parameters dxwn=-1.4e-08
parameters dvthn=0.03
parameters dlvthn=2.2e-09
parameters dwvthn=2.6e-09
parameters dpvthn=8e-16
parameters deta0n=0
parameters dleta0n=3e-09
parameters dpeta0n=0
parameters dpclmn=0
parameters dlpclmn=-2e-08
parameters dppclmn=0
parameters dpdiblc2n=0
parameters dlpdiblc2n=0
parameters dppdiblc2n=0
parameters dvoffn=0
parameters dlvoffn=-1.2e-09
parameters dpvoffn=-3e-16
parameters dcitn=-0.0002
parameters dlcitn=9e-11
parameters dpcitn=0
parameters du0n=0.0005
parameters dlu0n=0
parameters dpu0n=0
parameters dvsatn=0
parameters dlvsatn=0.00075
parameters dpvsatn=1.7e-10
parameters da0n=0
parameters dla0n=0
parameters dpa0n=0
parameters cjn=0.000981 * 1.05
parameters cjswn=1.185e-10 * 1.10
parameters cjswgn=3.82e-10 * 1.10
parameters dk2=0.01
parameters dlk2=0
parameters cgon=9.54839e-11 * (1 - 0.07)
parameters cgln=1.29912e-10 * (1 - 0.070)
parameters dlcn=3.73547e-10
parameters cfn=1.35e-10 * (1 - 0.070) + 3.57e-11 * ccoflag
parameters toxp=4.14e-09
parameters dxlp=1.15e-08
parameters dxwp=-1.4e-08
parameters dvthp=-0.03
parameters dlvthp=-3.80758e-09
parameters dwvthp=-5.0371268e-09
parameters dlpdiblc2p=-1.825e-10
parameters dwpdiblc2p=0
parameters dppdiblc2p=0
parameters dlpclmp=0
parameters dwpclmp=-8.82083e-09
parameters dppclmp=0
parameters dleta0p=-7.838e-09
parameters dweta0p=7.538e-09
parameters dpeta0p=0
parameters dlcitp=0
parameters dwcitp=-4.1864e-12
parameters dpcitp=-4.4186e-17
parameters dlnfactorp=0
parameters du0p=0.00018641
parameters dlu0p=0
parameters dwu0p=-4.4864e-11
parameters dwk2p=0
parameters dvoffp=-0.0031462
parameters dlvoffp=-1.022062e-09
parameters dwvoffp=-9.8262e-10
parameters dpvoffp=0
parameters dagsp=0.014862
parameters dlvsatp=0.003027415
parameters dwvsatp=0.0021716169
parameters dpvsatp=0
parameters dk2p=0.00782765
parameters dlk2p=4.82827e-10
parameters cjp=0.00112 * 1.05
parameters cjswp=1.345e-10 * 1.10
parameters cjswgp=4.36e-10 * 1.10
parameters cgop=9.87133e-12 * (1 - 0.07)
parameters cglp=2.74083e-10 * (1 - 0.070)
parameters dlcp=2.42932e-11
parameters cfp=1.35e-10 * (1 - 0.070) + 3.57e-11 * ccoflag
parameters a1fn=1.250e+42
parameters a2fn=7.000e+23
parameters a3fn=6.080e+7
parameters b1fn=-2.734e+41
parameters b2fn=-1.338e+23
parameters b3fn=-1.01e+7
parameters c1fn=6.10e+41
parameters c2fn=3.20e+23
parameters c3fn=3.04e+7
parameters a1fp=1.345e+42
parameters a2fp=5.000e+23
parameters a3fp=8.5e+9
parameters b1fp=-1.623e+41
parameters b2fp=-1.175e+23
parameters b3fp=-2.19e+9
parameters c1fp=3.50e+41
parameters c2fp=3.60e+23
parameters c3fp=6.50e+9
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "cmn018_assp_v1d2.scs" section=mos
 
endsection ss
 
// *****************************   LIBRARY OF FNFP CORNER CASE   *******************************

section ff
include "cmn018_assp_v1d2.scs" section=setup
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters toxn=3.901e-09
parameters dxln=-1.15e-08
parameters dxwn=1.4e-08
parameters dvthn=-0.03
parameters dlvthn=-1.7e-09
parameters dwvthn=-2.2e-09
parameters dpvthn=-8e-16
parameters deta0n=0
parameters dleta0n=-4e-09
parameters dpeta0n=0
parameters dpclmn=0
parameters dlpclmn=2e-08
parameters dppclmn=0
parameters dpdiblc2n=0
parameters dlpdiblc2n=0
parameters dppdiblc2n=0
parameters dvoffn=0
parameters dlvoffn=1.6e-09
parameters dpvoffn=3.1e-16
parameters dcitn=0.0002
parameters dlcitn=-9e-11
parameters dpcitn=0
parameters du0n=-0.0005
parameters dlu0n=0
parameters dpu0n=0
parameters dvsatn=0
parameters dlvsatn=-0.00055
parameters dpvsatn=-6.2e-11
parameters da0n=0
parameters dla0n=0
parameters dpa0n=0
parameters cjn=0.000981 * 0.95
parameters cjswn=1.185e-10 * 0.9
parameters cjswgn=3.82e-10 * 0.9
parameters dk2=-0.01
parameters dlk2=0
parameters cgon=9.54839e-11 * (1 + 0.07)
parameters cgln=1.29912e-10 * (1 + 0.070)
parameters dlcn=3.73547e-10
parameters cfn=1.35e-10 * (1 + 0.070) + 3.57e-11 * ccoflag
parameters toxp=3.98e-09
parameters dxlp=-1.15e-08
parameters dxwp=1.4e-08
parameters dvthp=0.03
parameters dlvthp=3.50834e-09
parameters dwvthp=8.1587659e-09
parameters dlpdiblc2p=2.25e-10
parameters dwpdiblc2p=0
parameters dppdiblc2p=0
parameters dlpclmp=-5.820834e-09
parameters dwpclmp=0
parameters dppclmp=0
parameters dleta0p=1.20834e-09
parameters dweta0p=0
parameters dpeta0p=0
parameters dlcitp=-1.418641e-11
parameters dwcitp=-1.285048e-11
parameters dpcitp=0
parameters dlnfactorp=0
parameters du0p=-0.00018641
parameters dlu0p=-4.48641e-11
parameters dwu0p=0
parameters dwk2p=0
parameters dvoffp=0.0030632
parameters dlvoffp=1.568628e-09
parameters dwvoffp=-2.2817632e-09
parameters dpvoffp=0
parameters dagsp=-0.0184624
parameters dlvsatp=-6.08e-05
parameters dwvsatp=-0.0016868851
parameters dpvsatp=0
parameters dk2p=-0.00782063
parameters dlk2p=-3.07282e-10
parameters cjp=0.00112 * 0.95
parameters cjswp=1.345e-10 * 0.9
parameters cjswgp=4.36e-10 * 0.9
parameters cgop=9.87133e-12 * (1 + 0.07)
parameters cglp=2.74083e-10 * (1 + 0.070)
parameters dlcp=2.42932e-11
parameters cfp=1.35e-10 * (1 + 0.070) + 3.57e-11 * ccoflag
parameters a1fn=1.250e+42
parameters a2fn=7.000e+23
parameters a3fn=6.080e+7
parameters b1fn=-2.734e+41
parameters b2fn=-1.338e+23
parameters b3fn=-1.01e+7
parameters c1fn=6.10e+41
parameters c2fn=3.20e+23
parameters c3fn=3.04e+7
parameters a1fp=1.345e+42
parameters a2fp=5.000e+23
parameters a3fp=8.5e+9
parameters b1fp=-1.623e+41
parameters b2fp=-1.175e+23
parameters b3fp=-2.19e+9
parameters c1fp=3.50e+41
parameters c2fp=3.60e+23
parameters c3fp=6.50e+9
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "cmn018_assp_v1d2.scs" section=mos
 
endsection ff
 
// *****************************   LIBRARY OF SNFP CORNER CASE   *******************************

section sf
include "cmn018_assp_v1d2.scs" section=setup
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters a1n=0.8
parameters a1p=-0.8
parameters a2n=0
parameters a2p=0
parameters a3n=-1
parameters a3p=1
parameters a4np=0
parameters toxn=3.981e-09 + 8.0000e-011 * a4np
parameters dxln=1.15e-008 * a2n
parameters dxwn=1.4e-008 * a3n
parameters dvthn=0.03 * a1n
parameters dlvthn=1.7e-009 * a1n
parameters dwvthn=2.2e-009 * a1n
parameters dpvthn=8e-016 * a1n
parameters deta0n=0
parameters dleta0n=4e-009 * a1n
parameters dpeta0n=0
parameters dpclmn=0
parameters dlpclmn= - 2e-008 * a1n
parameters dppclmn=0
parameters dpdiblc2n=0
parameters dlpdiblc2n=0
parameters dppdiblc2n=0
parameters dvoffn=0
parameters dlvoffn= - 1.6e-009 * a1n
parameters dpvoffn= - 3.1e-016 * a1n
parameters dcitn= - 0.0002 * a1n
parameters dlcitn=9e-011 * a1n
parameters dpcitn=0
parameters du0n=0.0005 * a1n
parameters dlu0n=0
parameters dpu0n=0
parameters dvsatn=0
parameters dlvsatn=0.00055 * a1n
parameters dpvsatn=6.2e-011 * a1n
parameters da0n=0
parameters dla0n=0
parameters dpa0n=0
parameters cjn=0.000981 * (1 + 0.05 * a1n)
parameters cjswn=1.185e-10 * (1 + 0.1 * a1n)
parameters cjswgn=3.82e-10 * (1 + 0.1 * a1n)
parameters dk2=0.01 * a1p
parameters dlk2=0
parameters cgon=9.54839e-11 * (1 - 0.07 * a4np)
parameters cgln=1.29912e-10 * (1 - 0.070 * a4np)
parameters dlcn=3.73547e-10
parameters cfn=1.35e-10 * (1 - 0.070 * a4np) + 3.57e-11 * ccoflag
parameters toxp=4.06e-09 + 8.0000e-011 * a4np
parameters dxlp=1.15e-008 * a2p
parameters dxwp=1.4e-008 * a3p
parameters dvthp= - 0.03 * a1p
parameters dlvthp= - 3.50834e-009 * a1p
parameters dwvthp= - 8.1587659e-009 * a1p
parameters dlpdiblc2p= - 2.25e-010 * a1p
parameters dwpdiblc2p=0
parameters dppdiblc2p=0
parameters dlpclmp=5.820834e-009 * a1p
parameters dwpclmp=0
parameters dppclmp=0
parameters dleta0p= - 1.20834e-009 * a1p
parameters dweta0p=0
parameters dpeta0p=0
parameters dlcitp=1.418641e-011 * a1p
parameters dwcitp=1.285048e-011 * a1p
parameters dpcitp=0
parameters dlnfactorp=0
parameters du0p=0.00018641 * a1p
parameters dlu0p=4.48641e-011 * a1p
parameters dwu0p=0
parameters dwk2p=0
parameters dvoffp= - 0.0030632 * a1p
parameters dlvoffp= - 1.568628e-009 * a1p
parameters dwvoffp=2.2817632e-009 * a1p
parameters dpvoffp=0
parameters dagsp=0.0184624 * a1p
parameters dlvsatp=6.08e-005 * a1p
parameters dwvsatp=0.0016868851 * a1p
parameters dpvsatp=0
parameters dk2p=0.00782063 * a1p
parameters dlk2p=3.07282e-010 * a1p
parameters cjp=0.00112 * (1 + 0.05 * a1p)
parameters cjswp=1.345e-10 * (1 + 0.1 * a1p)
parameters cjswgp=4.36e-10 * (1 + 0.1 * a1p)
parameters cgop=9.87133e-12 * (1 - 0.07 * a4np)
parameters cglp=2.74083e-10 * (1 - 0.070 * a4np)
parameters dlcp=2.42932e-11
parameters cfp=1.35e-10 * (1 - 0.070 * a4np) + 3.57e-11 * ccoflag
parameters a1fn=1.250e+42
parameters a2fn=7.000e+23
parameters a3fn=6.080e+7
parameters b1fn=-2.734e+41
parameters b2fn=-1.338e+23
parameters b3fn=-1.01e+7
parameters c1fn=6.10e+41
parameters c2fn=3.20e+23
parameters c3fn=3.04e+7
parameters a1fp=1.345e+42
parameters a2fp=5.000e+23
parameters a3fp=8.5e+9
parameters b1fp=-1.623e+41
parameters b2fp=-1.175e+23
parameters b3fp=-2.19e+9
parameters c1fp=3.50e+41
parameters c2fp=3.60e+23
parameters c3fp=6.50e+9
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "cmn018_assp_v1d2.scs" section=mos
 
endsection sf
 
// *****************************   LIBRARY OF FNSP CORNER CASE   *******************************

section fs
include "cmn018_assp_v1d2.scs" section=setup
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters a1n=-0.8
parameters a1p=0.8
parameters a2n=0
parameters a2p=0
parameters a3n=1
parameters a3p=-1
parameters a4np=0
parameters toxn=3.981e-09 + 8.0000e-011 * a4np
parameters dxln=1.15e-008 * a2n
parameters dxwn=1.4e-008 * a3n
parameters dvthn=0.03 * a1n
parameters dlvthn=1.7e-009 * a1n
parameters dwvthn=2.2e-009 * a1n
parameters dpvthn=8e-016 * a1n
parameters deta0n=0
parameters dleta0n=4e-009 * a1n
parameters dpeta0n=0
parameters dpclmn=0
parameters dlpclmn= - 2e-008 * a1n
parameters dppclmn=0
parameters dpdiblc2n=0
parameters dlpdiblc2n=0
parameters dppdiblc2n=0
parameters dvoffn=0
parameters dlvoffn= - 1.6e-009 * a1n
parameters dpvoffn= - 3.1e-016 * a1n
parameters dcitn= - 0.0002 * a1n
parameters dlcitn=9e-011 * a1n
parameters dpcitn=0
parameters du0n=0.0005 * a1n
parameters dlu0n=0
parameters dpu0n=0
parameters dvsatn=0
parameters dlvsatn=0.00055 * a1n
parameters dpvsatn=6.2e-011 * a1n
parameters da0n=0
parameters dla0n=0
parameters dpa0n=0
parameters cjn=0.000981 * (1 + 0.05 * a1n)
parameters cjswn=1.185e-10 * (1 + 0.1 * a1n)
parameters cjswgn=3.82e-10 * (1 + 0.1 * a1n)
parameters dk2=0.01 * a1p
parameters dlk2=0
parameters cgon=9.54839e-11 * (1 - 0.07 * a4np)
parameters cgln=1.29912e-10 * (1 - 0.070 * a4np)
parameters dlcn=3.73547e-10
parameters cfn=1.35e-10 * (1 - 0.070 * a4np) + 3.57e-11 * ccoflag
parameters toxp=4.06e-09 + 8.0000e-011 * a4np
parameters dxlp=1.15e-008 * a2p
parameters dxwp=1.4e-008 * a3p
parameters dvthp= - 0.03 * a1p
parameters dlvthp= - 3.50834e-009 * a1p
parameters dwvthp= - 8.1587659e-009 * a1p
parameters dlpdiblc2p= - 2.25e-010 * a1p
parameters dwpdiblc2p=0
parameters dppdiblc2p=0
parameters dlpclmp=5.820834e-009 * a1p
parameters dwpclmp=0
parameters dppclmp=0
parameters dleta0p= - 1.20834e-009 * a1p
parameters dweta0p=0
parameters dpeta0p=0
parameters dlcitp=1.418641e-011 * a1p
parameters dwcitp=1.285048e-011 * a1p
parameters dpcitp=0
parameters dlnfactorp=0
parameters du0p=0.00018641 * a1p
parameters dlu0p=4.48641e-011 * a1p
parameters dwu0p=0
parameters dwk2p=0
parameters dvoffp= - 0.0030632 * a1p
parameters dlvoffp= - 1.568628e-009 * a1p
parameters dwvoffp=2.2817632e-009 * a1p
parameters dpvoffp=0
parameters dagsp=0.0184624 * a1p
parameters dlvsatp=6.08e-005 * a1p
parameters dwvsatp=0.0016868851 * a1p
parameters dpvsatp=0
parameters dk2p=0.00782063 * a1p
parameters dlk2p=3.07282e-010 * a1p
parameters cjp=0.00112 * (1 + 0.05 * a1p)
parameters cjswp=1.345e-10 * (1 + 0.1 * a1p)
parameters cjswgp=4.36e-10 * (1 + 0.1 * a1p)
parameters cgop=9.87133e-12 * (1 - 0.07 * a4np)
parameters cglp=2.74083e-10 * (1 - 0.070 * a4np)
parameters dlcp=2.42932e-11
parameters cfp=1.35e-10 * (1 - 0.070 * a4np) + 3.57e-11 * ccoflag
parameters a1fn=1.250e+42
parameters a2fn=7.000e+23
parameters a3fn=6.080e+7
parameters b1fn=-2.734e+41
parameters b2fn=-1.338e+23
parameters b3fn=-1.01e+7
parameters c1fn=6.10e+41
parameters c2fn=3.20e+23
parameters c3fn=3.04e+7
parameters a1fp=1.345e+42
parameters a2fp=5.000e+23
parameters a3fp=8.5e+9
parameters b1fp=-1.623e+41
parameters b2fp=-1.175e+23
parameters b3fp=-2.19e+9
parameters c1fp=3.50e+41
parameters c2fp=3.60e+23
parameters c3fp=6.50e+9
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "cmn018_assp_v1d2.scs" section=mos
 
endsection fs
 
// *********************************************************************************************
 
// **************************************************************             
+                                                                              
+                                                                              
+                                                                              
+                                                                              
+                                                                              
//                                                      
//                                                              *             
+                                                                              
+                                                                              
+                                                                              
+                                                                              
+                                                                              
//                                                      
//                 3.3V NORMAL DEVICES LIB                      *             
+                                                                              
+                                                                              
+                                                                              
+                                                                              
//                      
//                                                              *             
+                                                                              
//                                                                 
// ************************************************************** 
// *****************************     LIBRARY OF TYPICAL CASE     *******************************

section tt_3v
include "cmn018_assp_v1d2.scs" section=setup_3v
parameters parn1_3v=0
parameters parn2_3v=0
parameters parp1_3v=0
parameters parp2_3v=0
parameters toxn_3v=6.700e-09
parameters dxln_3v=0
parameters dxwn_3v=0
parameters cjn_3v=8.92000e-04
parameters cjswn_3v=1.14000e-10
parameters cjswgn_3v=2.71000e-10
parameters dlcn_3v=4.224810e-08
parameters cgon_3v=3.179550e-11
parameters cgln_3v=1.848220e-10
parameters dvthn_3v=0
parameters dlvthn_3v=0
parameters dwvthn_3v=0
parameters dpvthn_3v=0
parameters du0n_3v=0
parameters dvsatn_3v=0
parameters dpvsatn_3v=0
parameters dk2n_3v=0
parameters dpatn_3v=0
parameters cfn_3v=1.36e-10 + 4.46e-11 * ccoflag_3v
parameters dlcitn_3v=0
parameters dpcitn_3v=0
parameters toxp_3v=6.794e-09
parameters dxlp_3v=0
parameters dxwp_3v=0
parameters cjp_3v=0.00101
parameters cjswp_3v=1.2e-10
parameters cjswgp_3v=2.6e-10
parameters dlcp_3v=2.70201e-08
parameters cgop_3v=52.457e-13
parameters cglp_3v=1.53609e-10
parameters dvthp_3v=0
parameters dlvthp_3v=0
parameters dwvthp_3v=0
parameters dpvthp_3v=0
parameters du0p_3v=0
parameters dvsatp_3v=0
parameters dpvsatp_3v=0
parameters dk2p_3v=0
parameters dlcitp_3v=0
parameters dpcitp_3v=0
parameters cfp_3v=1.35e-10 + 4.29e-11 * ccoflag_3v
parameters a1fn_3v=3.410e+42
parameters a2fn_3v=2.100e+23
parameters a3fn_3v=1.350e+6
parameters b1fn_3v=-5.230e+41
parameters b2fn_3v=-8.495e+22
parameters b3fn_3v=-5.425e+5
parameters c1fn_3v=1.30e+42
parameters c2fn_3v=2.13e+23
parameters c3fn_3v=1.52e+6
parameters a1fp_3v=1.860e+42
parameters a2fp_3v=4.750e+23
parameters a3fp_3v=1.150e+10
parameters b1fp_3v=-1.939e+41
parameters b2fp_3v=-1.298e+23
parameters b3fp_3v=-3.805e+9
parameters c1fp_3v=4.30e+41
parameters c2fp_3v=3.00e+23
parameters c3fp_3v=8.70e+9
parameters noian_3v=a1fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b1fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c1fn_3v
parameters noibn_3v=a2fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b2fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c2fn_3v
parameters noicn_3v=a3fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b3fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c3fn_3v
parameters noiap_3v=a1fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b1fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c1fp_3v
parameters noibp_3v=a2fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b2fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c2fp_3v
parameters noicp_3v=a3fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b3fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c3fp_3v
include "cmn018_assp_v1d2.scs" section=mos_3v
 
endsection tt_3v
 
// *****************************   LIBRARY OF SNSP CORNER CASE   *******************************

section ss_3v
include "cmn018_assp_v1d2.scs" section=setup_3v
parameters parn1_3v=0
parameters parn2_3v=0
parameters parp1_3v=0
parameters parp2_3v=0
parameters toxn_3v=6.900e-09
parameters dxln_3v=1.15e-08
parameters dxwn_3v=-1.40e-08
parameters cjn_3v=8.92000e-04 * 1.05
parameters cjswn_3v=1.14000e-10 * 1.1
parameters cjswgn_3v=2.98100e-10
parameters dlcn_3v=4.22481e-08
parameters cgon_3v=2.95698e-11
parameters cgln_3v=1.71884e-10
parameters dvthn_3v=2.20e-02
parameters dlvthn_3v=6.20e-09
parameters dwvthn_3v=2.50e-09
parameters dpvthn_3v=1.1e-15
parameters du0n_3v=-3.4e-4
parameters dvsatn_3v=-900
parameters dpvsatn_3v=-3.0e-10
parameters dk2n_3v=1.0e-2
parameters dpatn_3v=-4e-10
parameters cfn_3v=1.265e-10 + 4.46e-11 * ccoflag_3v
parameters dlcitn_3v=0
parameters dpcitn_3v=0
parameters toxp_3v=6.994e-09
parameters dxlp_3v=1.15e-08
parameters dxwp_3v=-1.4e-08
parameters cjp_3v=0.00101 * 1.05
parameters cjswp_3v=1.2e-10 * 1.1
parameters cjswgp_3v=2.86e-10
parameters dlcp_3v=2.70201e-08
parameters cgop_3v=48.785e-13
parameters cglp_3v=1.42856e-10
parameters dvthp_3v=-0.023
parameters dlvthp_3v=-6.7e-09
parameters dwvthp_3v=-2.2e-09
parameters dpvthp_3v=-5.5e-16
parameters du0p_3v=-2e-05
parameters dvsatp_3v=3200
parameters dpvsatp_3v=-9e-10
parameters dk2p_3v=0.01
parameters dlcitp_3v=0
parameters dpcitp_3v=0
parameters cfp_3v=1.2555e-10 + 4.29e-11 * ccoflag_3v
parameters a1fn_3v=3.410e+42
parameters a2fn_3v=2.100e+23
parameters a3fn_3v=1.350e+6
parameters b1fn_3v=-5.230e+41
parameters b2fn_3v=-8.495e+22
parameters b3fn_3v=-5.425e+5
parameters c1fn_3v=1.30e+42
parameters c2fn_3v=2.13e+23
parameters c3fn_3v=1.52e+6
parameters a1fp_3v=1.860e+42
parameters a2fp_3v=4.750e+23
parameters a3fp_3v=1.150e+10
parameters b1fp_3v=-1.939e+41
parameters b2fp_3v=-1.298e+23
parameters b3fp_3v=-3.805e+9
parameters c1fp_3v=4.30e+41
parameters c2fp_3v=3.00e+23
parameters c3fp_3v=8.70e+9
parameters noian_3v=a1fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b1fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c1fn_3v
parameters noibn_3v=a2fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b2fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c2fn_3v
parameters noicn_3v=a3fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b3fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c3fn_3v
parameters noiap_3v=a1fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b1fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c1fp_3v
parameters noibp_3v=a2fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b2fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c2fp_3v
parameters noicp_3v=a3fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b3fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c3fp_3v
include "cmn018_assp_v1d2.scs" section=mos_3v
 
endsection ss_3v
 
// *****************************   LIBRARY OF FNFP CORNER CASE   *******************************

section ff_3v
include "cmn018_assp_v1d2.scs" section=setup_3v
parameters parn1_3v=0
parameters parn2_3v=0
parameters parp1_3v=0
parameters parp2_3v=0
parameters toxn_3v=6.500e-09
parameters dxln_3v=-1.15e-08
parameters dxwn_3v=1.40e-08
parameters cjn_3v=8.92000e-04 * 0.95
parameters cjswn_3v=1.14000e-10 * 0.9
parameters cjswgn_3v=2.43900e-10
parameters dlcn_3v=4.22481e-08
parameters cgon_3v=3.40212e-11
parameters cgln_3v=1.97760e-10
parameters dvthn_3v=-2.30e-02
parameters dlvthn_3v=-5.0e-09
parameters dwvthn_3v=-2.50e-09
parameters dpvthn_3v=-1.2e-15
parameters du0n_3v=2.0e-4
parameters dvsatn_3v=-300
parameters dpvsatn_3v=2.5e-10
parameters dk2n_3v=-1.0e-2
parameters dpatn_3v=0
parameters cfn_3v=1.455e-10 + 4.46e-11 * ccoflag_3v
parameters dlcitn_3v=0
parameters dpcitn_3v=0
parameters toxp_3v=6.594e-09
parameters dxlp_3v=-1.15e-08
parameters dxwp_3v=1.4e-08
parameters cjp_3v=0.00101 * 0.95
parameters cjswp_3v=1.2e-10 * 0.9
parameters cjswgp_3v=2.34e-10
parameters dlcp_3v=2.70201e-08
parameters cgop_3v=56.129e-13
parameters cglp_3v=1.64362e-10
parameters dvthp_3v=0.023
parameters dlvthp_3v=5.9e-09
parameters dwvthp_3v=2.2e-09
parameters dpvthp_3v=7.5e-16
parameters du0p_3v=-3.6e-05
parameters dvsatp_3v=-4500
parameters dpvsatp_3v=5e-10
parameters dk2p_3v=-0.01
parameters dlcitp_3v=0
parameters dpcitp_3v=0
parameters cfp_3v=1.4445e-10 + 4.29e-11 * ccoflag_3v
parameters a1fn_3v=3.410e+42
parameters a2fn_3v=2.100e+23
parameters a3fn_3v=1.350e+6
parameters b1fn_3v=-5.230e+41
parameters b2fn_3v=-8.495e+22
parameters b3fn_3v=-5.425e+5
parameters c1fn_3v=1.30e+42
parameters c2fn_3v=2.13e+23
parameters c3fn_3v=1.52e+6
parameters a1fp_3v=1.860e+42
parameters a2fp_3v=4.750e+23
parameters a3fp_3v=1.150e+10
parameters b1fp_3v=-1.939e+41
parameters b2fp_3v=-1.298e+23
parameters b3fp_3v=-3.805e+9
parameters c1fp_3v=4.30e+41
parameters c2fp_3v=3.00e+23
parameters c3fp_3v=8.70e+9
parameters noian_3v=a1fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b1fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c1fn_3v
parameters noibn_3v=a2fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b2fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c2fn_3v
parameters noicn_3v=a3fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b3fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c3fn_3v
parameters noiap_3v=a1fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b1fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c1fp_3v
parameters noibp_3v=a2fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b2fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c2fp_3v
parameters noicp_3v=a3fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b3fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c3fp_3v
include "cmn018_assp_v1d2.scs" section=mos_3v
 
endsection ff_3v
 
// *****************************   LIBRARY OF SNFP CORNER CASE   *******************************

section sf_3v
include "cmn018_assp_v1d2.scs" section=setup_3v
parameters parn1_3v=0
parameters parn2_3v=0
parameters parp1_3v=0
parameters parp2_3v=0
parameters a1n_3v=0.5
parameters a1p_3v=-0.5
parameters a2n_3v=0
parameters a2p_3v=0
parameters a3n_3v=-1
parameters a3p_3v=1
parameters a4np_3v=0
parameters toxn_3v=6.700e-09 + 2.0000e-010 * a4np_3v
parameters dxln_3v=1.15e-008 * a2n_3v
parameters dxwn_3v=1.4e-008 * a3n_3v
parameters cjn_3v=8.92000e-04 * (1 + 0.050 * a1n_3v)
parameters cjswn_3v=1.14000e-10 * (1 + 0.100 * a1n_3v)
parameters cjswgn_3v=2.71000e-10 * (1 + 0.100 * a1n_3v)
parameters dlcn_3v=4.224810e-08 + 0.0000e+000 * a1n_3v
parameters cgon_3v=3.179550e-11 * (1 - 0.070 * a4np_3v)
parameters cgln_3v=1.848220e-10 * (1 - 0.070 * a4np_3v)
parameters dvthn_3v=0.023 * a1n_3v
parameters dlvthn_3v=5e-009 * a1n_3v
parameters dwvthn_3v=2.5e-009 * a1n_3v
parameters dpvthn_3v=1.2e-015 * a1n_3v
parameters du0n_3v= - 0.0002 * a1n_3v
parameters dvsatn_3v=300 * a1n_3v
parameters dpvsatn_3v= - 2.5e-010 * a1n_3v
parameters dk2n_3v=0.01 * a1n_3v
parameters dpatn_3v=0
parameters cfn_3v=1.36e-10 * (1 - 0.070 * a4np_3v) + 4.46e-11 * ccoflag_3v
parameters dlcitn_3v=0
parameters dpcitn_3v=0
parameters toxp_3v=6.794e-09 + 2.0000e-010 * a4np_3v
parameters dxlp_3v=1.15e-008 * a2p_3v
parameters dxwp_3v=1.4e-008 * a3p_3v
parameters cjp_3v=0.00101 * (1 + 0.050 * a1p_3v)
parameters cjswp_3v=1.2e-10 * (1 + 0.100 * a1p_3v)
parameters cjswgp_3v=2.6e-10 * (1 + 0.100 * a1p_3v)
parameters dlcp_3v=2.70201e-08
parameters cgop_3v=52.457e-13 * (1 - 0.070 * a4np_3v)
parameters cglp_3v=1.53609e-10 * (1 - 0.070 * a4np_3v)
parameters dvthp_3v= - 0.023 * a1p_3v
parameters dlvthp_3v= - 5.9e-009 * a1p_3v
parameters dwvthp_3v= - 2.2e-009 * a1p_3v
parameters dpvthp_3v= - 7.5e-016 * a1p_3v
parameters du0p_3v=3.6e-005 * a1p_3v
parameters dvsatp_3v=4500 * a1p_3v
parameters dpvsatp_3v= - 5e-010 * a1p_3v
parameters dk2p_3v=0.01 * a1p_3v
parameters dlcitp_3v=0
parameters dpcitp_3v=0
parameters cfp_3v=1.35e-10 * (1 - 0.070 * a4np_3v) + 4.29e-11 * ccoflag_3v
parameters a1fn_3v=3.410e+42
parameters a2fn_3v=2.100e+23
parameters a3fn_3v=1.350e+6
parameters b1fn_3v=-5.230e+41
parameters b2fn_3v=-8.495e+22
parameters b3fn_3v=-5.425e+5
parameters c1fn_3v=1.30e+42
parameters c2fn_3v=2.13e+23
parameters c3fn_3v=1.52e+6
parameters a1fp_3v=1.860e+42
parameters a2fp_3v=4.750e+23
parameters a3fp_3v=1.150e+10
parameters b1fp_3v=-1.939e+41
parameters b2fp_3v=-1.298e+23
parameters b3fp_3v=-3.805e+9
parameters c1fp_3v=4.30e+41
parameters c2fp_3v=3.00e+23
parameters c3fp_3v=8.70e+9
parameters noian_3v=a1fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b1fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c1fn_3v
parameters noibn_3v=a2fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b2fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c2fn_3v
parameters noicn_3v=a3fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b3fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c3fn_3v
parameters noiap_3v=a1fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b1fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c1fp_3v
parameters noibp_3v=a2fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b2fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c2fp_3v
parameters noicp_3v=a3fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b3fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c3fp_3v
include "cmn018_assp_v1d2.scs" section=mos_3v
 
endsection sf_3v
 
// *****************************   LIBRARY OF FNSP CORNER CASE   *******************************

section fs_3v
include "cmn018_assp_v1d2.scs" section=setup_3v
parameters parn1_3v=0
parameters parn2_3v=0
parameters parp1_3v=0
parameters parp2_3v=0
parameters a1n_3v=-0.5
parameters a1p_3v=0.5
parameters a2n_3v=0
parameters a2p_3v=0
parameters a3n_3v=1
parameters a3p_3v=-1
parameters a4np_3v=0
parameters toxn_3v=6.700e-09 + 2.0000e-010 * a4np_3v
parameters dxln_3v=1.15e-008 * a2n_3v
parameters dxwn_3v=1.4e-008 * a3n_3v
parameters cjn_3v=8.92000e-04 * (1 + 0.050 * a1n_3v)
parameters cjswn_3v=1.14000e-10 * (1 + 0.100 * a1n_3v)
parameters cjswgn_3v=2.71000e-10 * (1 + 0.100 * a1n_3v)
parameters dlcn_3v=4.224810e-08 + 0.0000e+000 * a1n_3v
parameters cgon_3v=3.179550e-11 * (1 - 0.070 * a4np_3v)
parameters cgln_3v=1.848220e-10 * (1 - 0.070 * a4np_3v)
parameters dvthn_3v=0.023 * a1n_3v
parameters dlvthn_3v=5e-009 * a1n_3v
parameters dwvthn_3v=2.5e-009 * a1n_3v
parameters dpvthn_3v=1.2e-015 * a1n_3v
parameters du0n_3v= - 0.0002 * a1n_3v
parameters dvsatn_3v=300 * a1n_3v
parameters dpvsatn_3v= - 2.5e-010 * a1n_3v
parameters dk2n_3v=0.01 * a1n_3v
parameters dpatn_3v=0
parameters cfn_3v=1.36e-10 * (1 - 0.070 * a4np_3v) + 4.46e-11 * ccoflag_3v
parameters dlcitn_3v=0
parameters dpcitn_3v=0
parameters toxp_3v=6.794e-09 + 2.0000e-010 * a4np_3v
parameters dxlp_3v=1.15e-008 * a2p_3v
parameters dxwp_3v=1.4e-008 * a3p_3v
parameters cjp_3v=0.00101 * (1 + 0.050 * a1p_3v)
parameters cjswp_3v=1.2e-10 * (1 + 0.100 * a1p_3v)
parameters cjswgp_3v=2.6e-10 * (1 + 0.100 * a1p_3v)
parameters dlcp_3v=2.70201e-08
parameters cgop_3v=52.457e-13 * (1 - 0.070 * a4np_3v)
parameters cglp_3v=1.53609e-10 * (1 - 0.070 * a4np_3v)
parameters dvthp_3v= - 0.023 * a1p_3v
parameters dlvthp_3v= - 5.9e-009 * a1p_3v
parameters dwvthp_3v= - 2.2e-009 * a1p_3v
parameters dpvthp_3v= - 7.5e-016 * a1p_3v
parameters du0p_3v=3.6e-005 * a1p_3v
parameters dvsatp_3v=4500 * a1p_3v
parameters dpvsatp_3v= - 5e-010 * a1p_3v
parameters dk2p_3v=0.01 * a1p_3v
parameters dlcitp_3v=0
parameters dpcitp_3v=0
parameters cfp_3v=1.35e-10 * (1 - 0.070 * a4np_3v) + 4.29e-11 * ccoflag_3v
parameters a1fn_3v=3.410e+42
parameters a2fn_3v=2.100e+23
parameters a3fn_3v=1.350e+6
parameters b1fn_3v=-5.230e+41
parameters b2fn_3v=-8.495e+22
parameters b3fn_3v=-5.425e+5
parameters c1fn_3v=1.30e+42
parameters c2fn_3v=2.13e+23
parameters c3fn_3v=1.52e+6
parameters a1fp_3v=1.860e+42
parameters a2fp_3v=4.750e+23
parameters a3fp_3v=1.150e+10
parameters b1fp_3v=-1.939e+41
parameters b2fp_3v=-1.298e+23
parameters b3fp_3v=-3.805e+9
parameters c1fp_3v=4.30e+41
parameters c2fp_3v=3.00e+23
parameters c3fp_3v=8.70e+9
parameters noian_3v=a1fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b1fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c1fn_3v
parameters noibn_3v=a2fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b2fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c2fn_3v
parameters noicn_3v=a3fn_3v * (abs(noiseflagn_3v) + noiseflagn_3v) + b3fn_3v * (abs(noiseflagn_3v) 
+ - noiseflagn_3v) + c3fn_3v
parameters noiap_3v=a1fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b1fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c1fp_3v
parameters noibp_3v=a2fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b2fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c2fp_3v
parameters noicp_3v=a3fp_3v * (abs(noiseflagp_3v) + noiseflagp_3v) + b3fp_3v * (abs(noiseflagp_3v) 
+ - noiseflagp_3v) + c3fp_3v
include "cmn018_assp_v1d2.scs" section=mos_3v
 
endsection fs_3v
 
// *********************************************************************************************
 
// **************************************************************
//                                                              *
//             1.8V MEDIUM VT  DEVICES LIB                      *  
//                                                              *
// **************************************************************
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_m
include "cmn018_assp_v1d2.scs" section=setup_m
parameters parn1m=0
parameters parn2m=0
parameters parp1m=0
parameters parp2m=0
parameters toxnm=3.981e-09
parameters dxlnm=0
parameters dxwnm=0
parameters dvthnm=0
parameters dlvthnm=0
parameters dwvthnm=0
parameters dpvthnm=0
parameters deta0nm=0
parameters dleta0nm=0
parameters dpeta0nm=0
parameters dpclmnm=0
parameters dlpclmnm=0
parameters dppclmnm=0
parameters dpdiblc2nm=0
parameters dlpdiblc2nm=0
parameters dppdiblc2nm=0
parameters dvoffnm=0
parameters dlvoffnm=0
parameters dpvoffnm=0
parameters dcitnm=0
parameters dlcitnm=0
parameters dpcitnm=0
parameters du0nm=0
parameters dlu0nm=0
parameters dpu0nm=0
parameters dvsatnm=0
parameters dlvsatnm=0
parameters dpvsatnm=0
parameters da0nm=0
parameters dla0nm=0
parameters dpa0nm=0
parameters dk2m=0
parameters dlk2m=0
parameters cjnm=0.000913
parameters cjswnm=1.04e-10
parameters cjswgnm=3.49e-10
parameters cgonm=2.087e-10
parameters cglnm=3.967e-12
parameters dlcnm=1.998e-08
parameters cfnm=1.35e-10 + 3.6e-11 * ccoflag_m
parameters toxpm=4.06e-09
parameters dxlpm=0
parameters dxwpm=0
parameters dvthpm=0
parameters dlvthpm=0
parameters dwvthpm=0
parameters dpvthpm=0
parameters dpdiblc2pm=0
parameters dlpdiblc2pm=0
parameters dwpdiblc2pm=0
parameters dppdiblc2pm=0
parameters dlpclmpm=0
parameters dwpclmpm=0
parameters dppclmpm=0
parameters deta0pm=0
parameters dleta0pm=0
parameters dweta0pm=0
parameters dpeta0pm=0
parameters dcitpm=0
parameters dlcitpm=0
parameters dwcitpm=0
parameters dpcitpm=0
parameters dlnfactorpm=0
parameters duapm=0
parameters dluapm=0
parameters dwuapm=0
parameters dpuapm=0
parameters dk2pm=0
parameters dlk2pm=0
parameters dwk2pm=0
parameters dpk2pm=0
parameters dvoffpm=0
parameters dlvoffpm=0
parameters dwvoffpm=0
parameters dpvoffpm=0
parameters dagspm=0
parameters dlvsatpm=0
parameters dwvsatpm=0
parameters dpvsatpm=0
parameters cjpm=0.00105
parameters cjswpm=1.26e-10
parameters cjswgpm=3.5e-10
parameters cgopm=2.681e-11
parameters cglpm=2.364e-10
parameters dlcpm=2.739e-08
parameters cfpm=1.35e-10 + 3.57e-11 * ccoflag_m
parameters a1fn_m=7.000e+41
parameters a2fn_m=2.940e+24
parameters a3fn_m=2.200e+8
parameters b1fn_m=-1.450e+41
parameters b2fn_m=-1.250e+24
parameters b3fn_m=-8.780e+7
parameters c1fn_m=3.30e+41
parameters c2fn_m=3.60e+24
parameters c3fn_m=2.14e+8
parameters a1fp_m=9.000e+41
parameters a2fp_m=2.500e+24
parameters a3fp_m=3.500e+9
parameters b1fp_m=-1.486e+41
parameters b2fp_m=-4.265e+23
parameters b3fp_m=-1.769e+9
parameters c1fp_m=3.520e+41
parameters c2fp_m=1.280e+24
parameters c3fp_m=4.320e+9
parameters noian_m=a1fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b1fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c1fn_m
parameters noibn_m=a2fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b2fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c2fn_m
parameters noicn_m=a3fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b3fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c3fn_m
parameters noiap_m=a1fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b1fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c1fp_m
parameters noibp_m=a2fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b2fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c2fp_m
parameters noicp_m=a3fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b3fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c3fp_m
include "cmn018_assp_v1d2.scs" section=mos_m
 
endsection tt_m
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_m
include "cmn018_assp_v1d2.scs" section=setup_m
parameters parn1m=0
parameters parn2m=0
parameters parp1m=0
parameters parp2m=0
parameters toxnm=4.061e-09
parameters dxlnm=1.15e-08
parameters dxwnm=-1.4e-08
parameters dvthnm=0.03
parameters dlvthnm=5.9e-09
parameters dwvthnm=4e-09
parameters dpvthnm=8e-16
parameters deta0nm=0
parameters dleta0nm=4e-09
parameters dpeta0nm=0
parameters dpclmnm=0
parameters dlpclmnm=-2e-08
parameters dppclmnm=0
parameters dpdiblc2nm=0
parameters dlpdiblc2nm=0
parameters dppdiblc2nm=0
parameters dvoffnm=0
parameters dlvoffnm=-4.8e-09
parameters dpvoffnm=-5e-16
parameters dcitnm=-0.0002
parameters dlcitnm=9e-11
parameters dpcitnm=-3e-18
parameters du0nm=0.0005
parameters dlu0nm=-5e-10
parameters dpu0nm=0
parameters dvsatnm=0
parameters dlvsatnm=0.00065
parameters dpvsatnm=7.8e-10
parameters da0nm=0
parameters dla0nm=0
parameters dpa0nm=8e-14
parameters dk2m=0.01
parameters dlk2m=0
parameters cjnm=0.000913 * 1.05
parameters cjswnm=1.04e-10 * 1.1
parameters cjswgnm=3.49e-10 * 1.1
parameters cgonm=1.941e-10
parameters cglnm=3.69e-12
parameters dlcnm=1.998e-08
parameters cfnm=1.256e-10 + 3.6e-11 * ccoflag_m
parameters toxpm=4.14e-09
parameters dxlpm=1.15e-08
parameters dxwpm=-1.4e-08
parameters dvthpm=-0.028
parameters dlvthpm=-7.8358e-09
parameters dwvthpm=-8.2e-09
parameters dpvthpm=0
parameters dpdiblc2pm=-0.001
parameters dlpdiblc2pm=0
parameters dwpdiblc2pm=0
parameters dppdiblc2pm=5e-16
parameters dlpclmpm=-1e-08
parameters dwpclmpm=-5e-08
parameters dppclmpm=0
parameters deta0pm=0
parameters dleta0pm=0
parameters dweta0pm=0
parameters dpeta0pm=0
parameters dcitpm=0
parameters dlcitpm=0
parameters dwcitpm=0
parameters dpcitpm=0
parameters dlnfactorpm=0
parameters duapm=0
parameters dluapm=0
parameters dwuapm=0
parameters dpuapm=0
parameters dk2pm=0.01282
parameters dlk2pm=0
parameters dwk2pm=0
parameters dpk2pm=0
parameters dvoffpm=-0.00561462
parameters dlvoffpm=-8.2568e-10
parameters dwvoffpm=-3.2568e-09
parameters dpvoffpm=0
parameters dagspm=0.02
parameters dlvsatpm=-0.002
parameters dwvsatpm=0
parameters dpvsatpm=4.5e-08
parameters cjpm=0.00105 * 1.05
parameters cjswpm=1.26e-10 * 1.1
parameters cjswgpm=3.5e-10 * 1.1
parameters cgopm=2.869e-11
parameters cglpm=2.529e-10
parameters dlcpm=2.739e-08
parameters cfpm=1.445e-10 + 3.57e-11 * ccoflag_m
parameters a1fn_m=7.000e+41
parameters a2fn_m=2.940e+24
parameters a3fn_m=2.200e+8
parameters b1fn_m=-1.450e+41
parameters b2fn_m=-1.250e+24
parameters b3fn_m=-8.780e+7
parameters c1fn_m=3.30e+41
parameters c2fn_m=3.60e+24
parameters c3fn_m=2.14e+8
parameters a1fp_m=9.000e+41
parameters a2fp_m=2.500e+24
parameters a3fp_m=3.500e+9
parameters b1fp_m=-1.486e+41
parameters b2fp_m=-4.265e+23
parameters b3fp_m=-1.769e+9
parameters c1fp_m=3.520e+41
parameters c2fp_m=1.280e+24
parameters c3fp_m=4.320e+9
parameters noian_m=a1fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b1fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c1fn_m
parameters noibn_m=a2fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b2fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c2fn_m
parameters noicn_m=a3fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b3fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c3fn_m
parameters noiap_m=a1fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b1fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c1fp_m
parameters noibp_m=a2fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b2fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c2fp_m
parameters noicp_m=a3fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b3fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c3fp_m
include "cmn018_assp_v1d2.scs" section=mos_m
 
endsection ss_m
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_m
include "cmn018_assp_v1d2.scs" section=setup_m
parameters parn1m=0
parameters parn2m=0
parameters parp1m=0
parameters parp2m=0
parameters toxnm=3.901e-09
parameters dxlnm=-1.15e-08
parameters dxwnm=1.4e-08
parameters dvthnm=-0.03
parameters dlvthnm=-6.8e-09
parameters dwvthnm=-3e-09
parameters dpvthnm=-8e-16
parameters deta0nm=0
parameters dleta0nm=-4e-09
parameters dpeta0nm=0
parameters dpclmnm=0
parameters dlpclmnm=2e-08
parameters dppclmnm=0
parameters dpdiblc2nm=0
parameters dlpdiblc2nm=0
parameters dppdiblc2nm=0
parameters dvoffnm=0
parameters dlvoffnm=5.8e-09
parameters dpvoffnm=4.8e-16
parameters dcitnm=0.0002
parameters dlcitnm=-9e-11
parameters dpcitnm=9.5e-18
parameters du0nm=-0.0005
parameters dlu0nm=4.5e-10
parameters dpu0nm=0
parameters dvsatnm=0
parameters dlvsatnm=-0.0006
parameters dpvsatnm=-2.3e-10
parameters da0nm=0
parameters dla0nm=0
parameters dpa0nm=-8e-14
parameters dk2m=-0.01
parameters dlk2m=0
parameters cjnm=0.000913 * 0.95
parameters cjswnm=1.04e-10 * 0.9
parameters cjswgnm=3.49e-10 * 0.9
parameters cgonm=2.233e-10
parameters cglnm=4.245e-12
parameters dlcnm=1.998e-08
parameters cfnm=1.445e-10 + 3.6e-11 * ccoflag_m
parameters toxpm=3.98e-09
parameters dxlpm=-1.15e-08
parameters dxwpm=1.4e-08
parameters dvthpm=0.028
parameters dlvthpm=7.5e-09
parameters dwvthpm=9.9e-09
parameters dpvthpm=0
parameters dpdiblc2pm=0.0005
parameters dlpdiblc2pm=1e-11
parameters dwpdiblc2pm=1e-10
parameters dppdiblc2pm=0
parameters dlpclmpm=0
parameters dwpclmpm=0
parameters dppclmpm=0
parameters deta0pm=0
parameters dleta0pm=0
parameters dweta0pm=0
parameters dpeta0pm=0
parameters dcitpm=0
parameters dlcitpm=0
parameters dwcitpm=0
parameters dpcitpm=0
parameters dlnfactorpm=0
parameters duapm=0
parameters dluapm=0
parameters dwuapm=0
parameters dpuapm=0
parameters dk2pm=-0.01282
parameters dlk2pm=0
parameters dwk2pm=0
parameters dpk2pm=0
parameters dvoffpm=0.0031462
parameters dlvoffpm=3.82568e-09
parameters dwvoffpm=1.2568e-09
parameters dpvoffpm=0
parameters dagspm=-0.015
parameters dlvsatpm=5e-05
parameters dwvsatpm=-0.0085
parameters dpvsatpm=0
parameters cjpm=0.00105 * 0.9
parameters cjswpm=1.26e-10 * 0.9
parameters cjswgpm=3.5e-10 * 0.9
parameters cgopm=2.493e-11
parameters cglpm=2.199e-10
parameters dlcpm=2.739e-08
parameters cfpm=1.256e-10 + 3.57e-11 * ccoflag_m
parameters a1fn_m=7.000e+41
parameters a2fn_m=2.940e+24
parameters a3fn_m=2.200e+8
parameters b1fn_m=-1.450e+41
parameters b2fn_m=-1.250e+24
parameters b3fn_m=-8.780e+7
parameters c1fn_m=3.30e+41
parameters c2fn_m=3.60e+24
parameters c3fn_m=2.14e+8
parameters a1fp_m=9.000e+41
parameters a2fp_m=2.500e+24
parameters a3fp_m=3.500e+9
parameters b1fp_m=-1.486e+41
parameters b2fp_m=-4.265e+23
parameters b3fp_m=-1.769e+9
parameters c1fp_m=3.520e+41
parameters c2fp_m=1.280e+24
parameters c3fp_m=4.320e+9
parameters noian_m=a1fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b1fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c1fn_m
parameters noibn_m=a2fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b2fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c2fn_m
parameters noicn_m=a3fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b3fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c3fn_m
parameters noiap_m=a1fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b1fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c1fp_m
parameters noibp_m=a2fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b2fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c2fp_m
parameters noicp_m=a3fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b3fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c3fp_m
include "cmn018_assp_v1d2.scs" section=mos_m
 
endsection ff_m
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_m
include "cmn018_assp_v1d2.scs" section=setup_m
parameters parn1m=0
parameters parn2m=0
parameters parp1m=0
parameters parp2m=0
parameters a1n_m=0.8
parameters a1p_m=-0.8
parameters a2n_m=0
parameters a2p_m=0
parameters a3n_m=-1
parameters a3p_m=1
parameters a4np_m=0
parameters toxnm=3.981e-09 + 8.0000e-011 * a4np_m
parameters dxlnm=1.15e-008 * a2n_m
parameters dxwnm=1.4e-008 * a3n_m
parameters dvthnm=0.03 * a1n_m
parameters dlvthnm=6.8e-009 * a1n_m
parameters dwvthnm=3e-009 * a1n_m
parameters dpvthnm=8e-016 * a1n_m
parameters deta0nm=0
parameters dleta0nm=4e-009 * a1n_m
parameters dpeta0nm=0
parameters dpclmnm=0
parameters dlpclmnm= - 2e-008 * a1n_m
parameters dppclmnm=0
parameters dpdiblc2nm=0
parameters dlpdiblc2nm=0
parameters dppdiblc2nm=0
parameters dvoffnm=0
parameters dlvoffnm= - 5.8e-009 * a1n_m
parameters dpvoffnm= - 4.8e-016 * a1n_m
parameters dcitnm= - 0.0002 * a1n_m
parameters dlcitnm=9e-011 * a1n_m
parameters dpcitnm= - 9.5e-018 * a1n_m
parameters du0nm=0.0005 * a1n_m
parameters dlu0nm= - 4.5e-010 * a1n_m
parameters dpu0nm=0
parameters dvsatnm=0
parameters dlvsatnm=0.0006 * a1n_m
parameters dpvsatnm=2.3e-010 * a1n_m
parameters da0nm=0
parameters dla0nm=0
parameters dpa0nm=8e-014 * a1n_m
parameters dk2m=0.01 * a1n_m
parameters dlk2m=0
parameters cjnm=0.000913 * (1 + 0.050 * a1n_m)
parameters cjswnm=1.04e-10 * (1 + 0.1 * a1n_m)
parameters cjswgnm=3.49e-10 * (1 + 0.1 * a1n_m)
parameters cgonm=2.087e-10 * (1 - 0.070 * a4np_m)
parameters cglnm=3.967e-12 * (1 - 0.070 * a4np_m)
parameters dlcnm=1.998e-08
parameters cfnm=1.35e-10 * (1 - 0.070 * a4np_m) + 3.6e-11 * ccoflag_m
parameters toxpm=4.06e-09 + 8.0000e-011 * a4np_m
parameters dxlpm=1.15e-008 * a2p_m
parameters dxwpm=1.4e-008 * a3p_m
parameters dvthpm= - 0.028 * a1p_m
parameters dlvthpm= - 7.5e-009 * a1p_m
parameters dwvthpm= - 9.9e-009 * a1p_m
parameters dpvthpm=0
parameters dpdiblc2pm= - 0.0005 * a1p_m
parameters dlpdiblc2pm= - 1e-011 * a1p_m
parameters dwpdiblc2pm= - 1e-010 * a1p_m
parameters dppdiblc2pm=0
parameters dlpclmpm=0
parameters dwpclmpm=0
parameters dppclmpm=0
parameters deta0pm=0
parameters dleta0pm=0
parameters dweta0pm=0
parameters dpeta0pm=0
parameters dcitpm=0
parameters dlcitpm=0
parameters dwcitpm=0
parameters dpcitpm=0
parameters dlnfactorpm=0
parameters duapm=0
parameters dluapm=0
parameters dwuapm=0
parameters dpuapm=0
parameters dk2pm=0.01282 * a1p_m
parameters dlk2pm=0
parameters dwk2pm=0
parameters dpk2pm=0
parameters dvoffpm= - 0.0031462 * a1p_m
parameters dlvoffpm= - 3.82568e-009 * a1p_m
parameters dwvoffpm= - 1.2568e-009 * a1p_m
parameters dpvoffpm=0
parameters dagspm=0.015 * a1p_m
parameters dlvsatpm= - 5e-005 * a1p_m
parameters dwvsatpm=0.0085 * a1p_m
parameters dpvsatpm=0
parameters cjpm=0.00105 * (1 + 0.050 * a1p_m)
parameters cjswpm=1.26e-10 * (1 + 0.1 * a1p_m)
parameters cjswgpm=3.5e-10 * (1 + 0.1 * a1p_m)
parameters cgopm=2.681e-11 * (1 - 0.070 * a4np_m)
parameters cglpm=2.364e-10 * (1 - 0.070 * a4np_m)
parameters dlcpm=2.739e-08
parameters cfpm=1.35e-10 * (1 - 0.070 * a4np_m) + 3.57e-11 * ccoflag_m
parameters a1fn_m=7.000e+41
parameters a2fn_m=2.940e+24
parameters a3fn_m=2.200e+8
parameters b1fn_m=-1.450e+41
parameters b2fn_m=-1.250e+24
parameters b3fn_m=-8.780e+7
parameters c1fn_m=3.30e+41
parameters c2fn_m=3.60e+24
parameters c3fn_m=2.14e+8
parameters a1fp_m=9.000e+41
parameters a2fp_m=2.500e+24
parameters a3fp_m=3.500e+9
parameters b1fp_m=-1.486e+41
parameters b2fp_m=-4.265e+23
parameters b3fp_m=-1.769e+9
parameters c1fp_m=3.520e+41
parameters c2fp_m=1.280e+24
parameters c3fp_m=4.320e+9
parameters noian_m=a1fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b1fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c1fn_m
parameters noibn_m=a2fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b2fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c2fn_m
parameters noicn_m=a3fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b3fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c3fn_m
parameters noiap_m=a1fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b1fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c1fp_m
parameters noibp_m=a2fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b2fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c2fp_m
parameters noicp_m=a3fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b3fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c3fp_m
include "cmn018_assp_v1d2.scs" section=mos_m
 
endsection sf_m
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_m
include "cmn018_assp_v1d2.scs" section=setup_m
parameters parn1m=0
parameters parn2m=0
parameters parp1m=0
parameters parp2m=0
parameters a1n_m=-0.8
parameters a1p_m=0.8
parameters a2n_m=0
parameters a2p_m=0
parameters a3n_m=1
parameters a3p_m=-1
parameters a4np_m=0
parameters toxnm=3.981e-09 + 8.0000e-011 * a4np_m
parameters dxlnm=1.15e-008 * a2n_m
parameters dxwnm=1.4e-008 * a3n_m
parameters dvthnm=0.03 * a1n_m
parameters dlvthnm=6.8e-009 * a1n_m
parameters dwvthnm=3e-009 * a1n_m
parameters dpvthnm=8e-016 * a1n_m
parameters deta0nm=0
parameters dleta0nm=4e-009 * a1n_m
parameters dpeta0nm=0
parameters dpclmnm=0
parameters dlpclmnm= - 2e-008 * a1n_m
parameters dppclmnm=0
parameters dpdiblc2nm=0
parameters dlpdiblc2nm=0
parameters dppdiblc2nm=0
parameters dvoffnm=0
parameters dlvoffnm= - 5.8e-009 * a1n_m
parameters dpvoffnm= - 4.8e-016 * a1n_m
parameters dcitnm= - 0.0002 * a1n_m
parameters dlcitnm=9e-011 * a1n_m
parameters dpcitnm= - 9.5e-018 * a1n_m
parameters du0nm=0.0005 * a1n_m
parameters dlu0nm= - 4.5e-010 * a1n_m
parameters dpu0nm=0
parameters dvsatnm=0
parameters dlvsatnm=0.0006 * a1n_m
parameters dpvsatnm=2.3e-010 * a1n_m
parameters da0nm=0
parameters dla0nm=0
parameters dpa0nm=8e-014 * a1n_m
parameters dk2m=0.01 * a1n_m
parameters dlk2m=0
parameters cjnm=0.000913 * (1 + 0.05 * a1n_m)
parameters cjswnm=1.04e-10 * (1 + 0.1 * a1n_m)
parameters cjswgnm=3.49e-10 * (1 + 0.1 * a1n_m)
parameters cgonm=2.087e-10 * (1 - 0.070 * a4np_m)
parameters cglnm=3.967e-12 * (1 - 0.070 * a4np_m)
parameters dlcnm=1.998e-08
parameters cfnm=1.35e-10 * (1 - 0.070 * a4np_m) + 3.6e-11 * ccoflag_m
parameters toxpm=4.06e-09 + 8.0000e-011 * a4np_m
parameters dxlpm=1.15e-008 * a2p_m
parameters dxwpm=1.4e-008 * a3p_m
parameters dvthpm= - 0.028 * a1p_m
parameters dlvthpm= - 7.5e-009 * a1p_m
parameters dwvthpm= - 9.9e-009 * a1p_m
parameters dpvthpm=0
parameters dpdiblc2pm= - 0.0005 * a1p_m
parameters dlpdiblc2pm= - 1e-011 * a1p_m
parameters dwpdiblc2pm= - 1e-010 * a1p_m
parameters dppdiblc2pm=0
parameters dlpclmpm=0
parameters dwpclmpm=0
parameters dppclmpm=0
parameters deta0pm=0
parameters dleta0pm=0
parameters dweta0pm=0
parameters dpeta0pm=0
parameters dcitpm=0
parameters dlcitpm=0
parameters dwcitpm=0
parameters dpcitpm=0
parameters dlnfactorpm=0
parameters duapm=0
parameters dluapm=0
parameters dwuapm=0
parameters dpuapm=0
parameters dk2pm=0.01282 * a1p_m
parameters dlk2pm=0
parameters dwk2pm=0
parameters dpk2pm=0
parameters dvoffpm= - 0.0031462 * a1p_m
parameters dlvoffpm= - 3.82568e-009 * a1p_m
parameters dwvoffpm= - 1.2568e-009 * a1p_m
parameters dpvoffpm=0
parameters dagspm=0.015 * a1p_m
parameters dlvsatpm= - 5e-005 * a1p_m
parameters dwvsatpm=0.0085 * a1p_m
parameters dpvsatpm=0
parameters cjpm=0.00105 * (1 + 0.05 * a1p_m)
parameters cjswpm=1.26e-10 * (1 + 0.1 * a1p_m)
parameters cjswgpm=3.5e-10 * (1 + 0.1 * a1p_m)
parameters cgopm=2.681e-11 * (1 - 0.070 * a4np_m)
parameters cglpm=2.364e-10 * (1 - 0.070 * a4np_m)
parameters dlcpm=2.739e-08
parameters cfpm=1.35e-10 * (1 - 0.070 * a4np_m) + 3.57e-11 * ccoflag_m
parameters a1fn_m=7.000e+41
parameters a2fn_m=2.940e+24
parameters a3fn_m=2.200e+8
parameters b1fn_m=-1.450e+41
parameters b2fn_m=-1.250e+24
parameters b3fn_m=-8.780e+7
parameters c1fn_m=3.30e+41
parameters c2fn_m=3.60e+24
parameters c3fn_m=2.14e+8
parameters a1fp_m=9.000e+41
parameters a2fp_m=2.500e+24
parameters a3fp_m=3.500e+9
parameters b1fp_m=-1.486e+41
parameters b2fp_m=-4.265e+23
parameters b3fp_m=-1.769e+9
parameters c1fp_m=3.520e+41
parameters c2fp_m=1.280e+24
parameters c3fp_m=4.320e+9
parameters noian_m=a1fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b1fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c1fn_m
parameters noibn_m=a2fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b2fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c2fn_m
parameters noicn_m=a3fn_m * (abs(noiseflagn_m) + noiseflagn_m) + b3fn_m * (abs(noiseflagn_m) 
+ - noiseflagn_m) + c3fn_m
parameters noiap_m=a1fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b1fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c1fp_m
parameters noibp_m=a2fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b2fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c2fp_m
parameters noicp_m=a3fp_m * (abs(noiseflagp_m) + noiseflagp_m) + b3fp_m * (abs(noiseflagp_m) 
+ - noiseflagp_m) + c3fp_m
include "cmn018_assp_v1d2.scs" section=mos_m
 
endsection fs_m
 
// *********************************************************************************************
// **************************************************************
//                                                              *
//             3.3V MEDIUM VT  DEVICES LIB                      *  
//                                                              *
// **************************************************************
// *****************************     LIBRARY OF TYPICAL CASE     *******************************

section tt_3m
include "cmn018_assp_v1d2.scs" section=setup_3m
parameters parn1_3m=0
parameters parn2_3m=0
parameters toxn_3m=6.700e-09
parameters dxln_3m=0
parameters dxwn_3m=0
parameters cjn_3m=8.72000e-04
parameters cjswn_3m=1.22000e-10
parameters cjswgn_3m=2.44000e-10
parameters dlcn_3m=6.381350e-08
parameters cgon_3m=2.027240e-11
parameters cgln_3m=3.106500e-10
parameters dvthn_3m=0
parameters dlvthn_3m=0
parameters dwvthn_3m=0
parameters dpvthn_3m=0
parameters du0n_3m=0
parameters dvsatn_3m=0
parameters dpvsatn_3m=0
parameters dk2n_3m=0
parameters dlcitn_3m=0
parameters dpcitn_3m=0
parameters cfn_3m=1.36e-10 + 4.46e-11 * ccoflag_3m
parameters a1fn_3m=3.245e+42
parameters a2fn_3m=1.415e+24
parameters a3fn_3m=5.280e+7
parameters b1fn_3m=-9.975e+41
parameters b2fn_3m=-4.220e+23
parameters b3fn_3m=-3.385e+7
parameters c1fn_3m=2.12e+42
parameters c2fn_3m=1.28e+24
parameters c3fn_3m=8.32e+7
parameters noian_3m=a1fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b1fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c1fn_3m
parameters noibn_3m=a2fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b2fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c2fn_3m
parameters noicn_3m=a3fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b3fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c3fn_3m
include "cmn018_assp_v1d2.scs" section=mos_3m
 
endsection tt_3m
 
// *****************************   LIBRARY OF SNSP CORNER CASE   *******************************

section ss_3m
include "cmn018_assp_v1d2.scs" section=setup_3m
parameters parn1_3m=0
parameters parn2_3m=0
parameters toxn_3m=6.900e-09
parameters dxln_3m=1.15e-08
parameters dxwn_3m=-1.40e-08
parameters cjn_3m=8.72000e-04 * 1.05
parameters cjswn_3m=1.22000e-10 * 1.1
parameters cjswgn_3m=2.684e-10
parameters dlcn_3m=6.381350e-08
parameters cgon_3m=1.88533e-11
parameters cgln_3m=2.88905e-10
parameters dvthn_3m=2.6e-02
parameters dlvthn_3m=1.15e-08
parameters dwvthn_3m=2.8e-09
parameters dpvthn_3m=0.8e-15
parameters du0n_3m=-0.00061
parameters dvsatn_3m=-250
parameters dpvsatn_3m=-0.63e-9
parameters dk2n_3m=1.0e-2
parameters dlcitn_3m=0
parameters dpcitn_3m=0
parameters cfn_3m=1.2648e-10 + 4.46e-11 * ccoflag_3m
parameters a1fn_3m=3.245e+42
parameters a2fn_3m=1.415e+24
parameters a3fn_3m=5.280e+7
parameters b1fn_3m=-9.975e+41
parameters b2fn_3m=-4.220e+23
parameters b3fn_3m=-3.385e+7
parameters c1fn_3m=2.12e+42
parameters c2fn_3m=1.28e+24
parameters c3fn_3m=8.32e+7
parameters noian_3m=a1fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b1fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c1fn_3m
parameters noibn_3m=a2fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b2fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c2fn_3m
parameters noicn_3m=a3fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b3fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c3fn_3m
include "cmn018_assp_v1d2.scs" section=mos_3m
 
endsection ss_3m
 
// *****************************   LIBRARY OF FNFP CORNER CASE   *******************************

section ff_3m
include "cmn018_assp_v1d2.scs" section=setup_3m
parameters parn1_3m=0
parameters parn2_3m=0
parameters toxn_3m=6.500e-09
parameters dxln_3m=-1.15e-08
parameters dxwn_3m=1.40e-08
parameters cjn_3m=8.72000e-04 * 0.95
parameters cjswn_3m=1.22000e-10 * 0.9
parameters cjswgn_3m=2.196e-10
parameters dlcn_3m=6.381350e-08
parameters cgon_3m=2.16915e-11
parameters cgln_3m=3.32396e-10
parameters dvthn_3m=-2.60e-02
parameters dlvthn_3m=-1.10e-08
parameters dwvthn_3m=-2.8e-09
parameters dpvthn_3m=-1.05e-15
parameters du0n_3m=0.00048
parameters dvsatn_3m=-350
parameters dpvsatn_3m=0.56e-9
parameters dk2n_3m=-1.0e-2
parameters dlcitn_3m=0
parameters dpcitn_3m=0
parameters cfn_3m=1.4552e-10 + 4.46e-11 * ccoflag_3m
parameters a1fn_3m=3.245e+42
parameters a2fn_3m=1.415e+24
parameters a3fn_3m=5.280e+7
parameters b1fn_3m=-9.975e+41
parameters b2fn_3m=-4.220e+23
parameters b3fn_3m=-3.385e+7
parameters c1fn_3m=2.12e+42
parameters c2fn_3m=1.28e+24
parameters c3fn_3m=8.32e+7
parameters noian_3m=a1fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b1fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c1fn_3m
parameters noibn_3m=a2fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b2fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c2fn_3m
parameters noicn_3m=a3fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b3fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c3fn_3m
include "cmn018_assp_v1d2.scs" section=mos_3m
 
endsection ff_3m
 
// *****************************   LIBRARY OF SNFP CORNER CASE   *******************************

section sf_3m
include "cmn018_assp_v1d2.scs" section=setup_3m
parameters parn1_3m=0
parameters parn2_3m=0
parameters a1n_3m=0.8
parameters a2n_3m=0
parameters a3n_3m=-1
parameters a4n_3m=0
parameters a5n_3m=0
parameters toxn_3m=6.700e-09 + 2.0000e-010 * a4n_3m
parameters dxln_3m=1.15e-008 * a2n_3m
parameters dxwn_3m=1.4e-008 * a3n_3m
parameters cjn_3m=8.720e-04 + 4.360e-05 * a1n_3m
parameters cjswn_3m=1.220e-10 + 1.220e-11 * a1n_3m
parameters cjswgn_3m=2.440e-10 + 2.440e-11 * a1n_3m
parameters dlcn_3m=6.381350e-08
parameters cgon_3m=2.027240e-11 +  - 1.4191e-012 * a1n_3m
parameters cgln_3m=3.106500e-10 +  - 2.1746e-011 * a1n_3m
parameters dvthn_3m=0.026 * a1n_3m
parameters dlvthn_3m=1.1e-008 * a1n_3m
parameters dwvthn_3m=2.8e-009 * a1n_3m
parameters dpvthn_3m=1.05e-015 * a1n_3m
parameters du0n_3m= - 0.00048 * a1n_3m
parameters dvsatn_3m=350 * a1n_3m
parameters dpvsatn_3m= - 5.6e-010 * a1n_3m
parameters dk2n_3m=0.01 * a1n_3m
parameters dlcitn_3m=0
parameters dpcitn_3m=0
parameters cfn_3m=1.36e-10 * (1 - 0.070 * a4n_3m) + 4.46e-11 * ccoflag_3m
parameters a1fn_3m=3.245e+42
parameters a2fn_3m=1.415e+24
parameters a3fn_3m=5.280e+7
parameters b1fn_3m=-9.975e+41
parameters b2fn_3m=-4.220e+23
parameters b3fn_3m=-3.385e+7
parameters c1fn_3m=2.12e+42
parameters c2fn_3m=1.28e+24
parameters c3fn_3m=8.32e+7
parameters noian_3m=a1fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b1fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c1fn_3m
parameters noibn_3m=a2fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b2fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c2fn_3m
parameters noicn_3m=a3fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b3fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c3fn_3m
include "cmn018_assp_v1d2.scs" section=mos_3m
 
endsection sf_3m
 
// *****************************   LIBRARY OF FNSP CORNER CASE   *******************************

section fs_3m
include "cmn018_assp_v1d2.scs" section=setup_3m
parameters parn1_3m=0
parameters parn2_3m=0
parameters a1n_3m=-0.8
parameters a2n_3m=0
parameters a3n_3m=1
parameters a4n_3m=0
parameters a5n_3m=0
parameters toxn_3m=6.700e-09 + 2.0000e-010 * a4n_3m
parameters dxln_3m=1.15e-008 * a2n_3m
parameters dxwn_3m=1.4e-008 * a3n_3m
parameters cjn_3m=8.720e-04 + 4.360e-05 * a1n_3m
parameters cjswn_3m=1.220e-10 + 1.220e-11 * a1n_3m
parameters cjswgn_3m=2.440e-10 + 2.440e-11 * a1n_3m
parameters dlcn_3m=6.381350e-08
parameters cgon_3m=2.027240e-11 +  - 1.4191e-012 * a1n_3m
parameters cgln_3m=3.106500e-10 +  - 2.1746e-011 * a1n_3m
parameters dvthn_3m=0.026 * a1n_3m
parameters dlvthn_3m=1.1e-008 * a1n_3m
parameters dwvthn_3m=2.8e-009 * a1n_3m
parameters dpvthn_3m=1.05e-015 * a1n_3m
parameters du0n_3m= - 0.00048 * a1n_3m
parameters dvsatn_3m=350 * a1n_3m
parameters dpvsatn_3m= - 5.6e-010 * a1n_3m
parameters dk2n_3m=0.01 * a1n_3m
parameters dlcitn_3m=0
parameters dpcitn_3m=0
parameters cfn_3m=1.36e-10 * (1 - 0.070 * a4n_3m) + 4.46e-11 * ccoflag_3m
parameters a1fn_3m=3.245e+42
parameters a2fn_3m=1.415e+24
parameters a3fn_3m=5.280e+7
parameters b1fn_3m=-9.975e+41
parameters b2fn_3m=-4.220e+23
parameters b3fn_3m=-3.385e+7
parameters c1fn_3m=2.12e+42
parameters c2fn_3m=1.28e+24
parameters c3fn_3m=8.32e+7
parameters noian_3m=a1fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b1fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c1fn_3m
parameters noibn_3m=a2fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b2fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c2fn_3m
parameters noicn_3m=a3fn_3m * (abs(noiseflagn_3m) + noiseflagn_3m) + b3fn_3m * (abs(noiseflagn_3m) 
+ - noiseflagn_3m) + c3fn_3m
include "cmn018_assp_v1d2.scs" section=mos_3m
 
endsection fs_3m
 
// *********************************************************************************************
 
// **************************************************************
//                                                              *
//             1.8V Native VT  DEVICES LIB                      *  
//                                                              *
// **************************************************************
// *****************************     LIBRARY OF TYPICAL CASE     *******************************

section tt_na
include "cmn018_assp_v1d2.scs" section=setup_na
parameters parn1_na=0
parameters parn2_na=0
parameters toxn_na=3.986e-009
parameters dxln_na=0
parameters dxwn_na=0
parameters dvth0n_na=0
parameters dlvth0n_na=0
parameters dwvth0n_na=0
parameters du0n_na=0
parameters dlu0n_na=0
parameters dpu0n_na=0
parameters dk2n_na=0
parameters dwk2n_na=0
parameters dlvoffn_na=0
parameters dpvoffn_na=0
parameters cjn_na=9.81e-04
parameters cjswn_na=1.185e-10
parameters cjswgn_na=3.82667e-10
parameters cgon_na=7.508600e-12
parameters cgln_na=8.691250e-10
parameters dlcn_na=1.012840e-07
parameters cfn_na=1.350e-10 + 3.57e-11 * ccoflag_na
parameters a1fn_na=4.529e+42
parameters a2fn_na=3.500e+23
parameters a3fn_na=1.510e+6
parameters b1fn_na=-6.730e+41
parameters b2fn_na=-1.535e+23
parameters b3fn_na=-5.855e+7
parameters c1fn_na=1.542e+42
parameters c2fn_na=4.400e+23
parameters c3fn_na=1.600e+6
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "cmn018_assp_v1d2.scs" section=mos_na
 
endsection tt_na
 
// *****************************   LIBRARY OF SNSP CORNER CASE   *******************************

section ss_na
include "cmn018_assp_v1d2.scs" section=setup_na
parameters parn1_na=0
parameters parn2_na=0
parameters toxn_na=4.186e-09
parameters dxln_na=1.15e-08
parameters dxwn_na=-1.40e-08
parameters dvth0n_na=0.07
parameters dlvth0n_na=3.5e-9
parameters dwvth0n_na=1.9e-9
parameters du0n_na=0.00435
parameters dlu0n_na=-9.5e-10
parameters dpu0n_na=-5.6e-16
parameters dk2n_na=0.0e-2
parameters dwk2n_na=1.5e-9
parameters dlvoffn_na=0
parameters dpvoffn_na=0
parameters cjn_na=9.81e-04 * 1.05
parameters cjswn_na=1.185e-10 * 1.1
parameters cjswgn_na=4.20934e-10
parameters cgon_na=6.98300e-12
parameters cgln_na=8.08286e-10
parameters dlcn_na=1.01284e-07
parameters cfn_na=1.256e-10 + 3.57e-11 * ccoflag_na
parameters a1fn_na=4.529e+42
parameters a2fn_na=3.500e+23
parameters a3fn_na=1.510e+6
parameters b1fn_na=-6.730e+41
parameters b2fn_na=-1.535e+23
parameters b3fn_na=-5.855e+7
parameters c1fn_na=1.542e+42
parameters c2fn_na=4.400e+23
parameters c3fn_na=1.600e+6
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "cmn018_assp_v1d2.scs" section=mos_na
 
endsection ss_na
 
// *****************************   LIBRARY OF FNFP CORNER CASE   *******************************

section ff_na
include "cmn018_assp_v1d2.scs" section=setup_na
parameters parn1_na=0
parameters parn2_na=0
parameters toxn_na=3.786e-09
parameters dxln_na=-1.15e-08
parameters dxwn_na=1.40e-08
parameters dvth0n_na=-0.0695
parameters dlvth0n_na=-4.0e-9
parameters dwvth0n_na=-2.4e-9
parameters du0n_na=-0.00395
parameters dlu0n_na=1.8e-10
parameters dpu0n_na=2.6e-16
parameters dk2n_na=-0.0e-2
parameters dwk2n_na=-1.5e-9
parameters dlvoffn_na=0
parameters dpvoffn_na=0
parameters cjn_na=9.81e-04 * 0.95
parameters cjswn_na=1.185e-10 * 0.9
parameters cjswgn_na=3.44400e-10
parameters cgon_na=8.03420e-12
parameters cgln_na=9.29964e-10
parameters dlcn_na=1.01284e-07
parameters cfn_na=1.445e-10 + 3.57e-11 * ccoflag_na
parameters a1fn_na=4.529e+42
parameters a2fn_na=3.500e+23
parameters a3fn_na=1.510e+6
parameters b1fn_na=-6.730e+41
parameters b2fn_na=-1.535e+23
parameters b3fn_na=-5.855e+7
parameters c1fn_na=1.542e+42
parameters c2fn_na=4.400e+23
parameters c3fn_na=1.600e+6
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "cmn018_assp_v1d2.scs" section=mos_na
 
endsection ff_na
 
// *****************************   LIBRARY OF SNFP CORNER CASE   *******************************

section sf_na
include "cmn018_assp_v1d2.scs" section=setup_na
parameters parn1_na=0
parameters parn2_na=0
parameters a1n_na=0.8
parameters a2n_na=0
parameters a3n_na=-1
parameters a4np_na=0
parameters a5n_na=0
parameters toxn_na=3.986e-009 + 2.0000e-010 * a4np_na
parameters dxln_na=1.15e-008 * a2n_na
parameters dxwn_na=1.4e-008 * a3n_na
parameters dvth0n_na=0.0695 * a1n_na
parameters dlvth0n_na=4e-009 * a1n_na
parameters dwvth0n_na=2.4e-009 * a1n_na
parameters du0n_na=0.00395 * a1n_na
parameters dlu0n_na= - 1.8e-010 * a1n_na
parameters dpu0n_na= - 2.6e-016 * a1n_na
parameters dk2n_na=0 * a1n_na
parameters dwk2n_na=1.5e-009 * a1n_na
parameters dlvoffn_na=0
parameters dpvoffn_na=0
parameters cjn_na=9.81e-04 * (1 + 0.050 * a1n_na)
parameters cjswn_na=1.185e-10 * (1 + 0.100 * a1n_na)
parameters cjswgn_na=3.82667e-10 * (1 + 0.100 * a1n_na)
parameters cgon_na=7.508600e-12 * (1 - 0.070 * a4np_na)
parameters cgln_na=8.691250e-10 * (1 - 0.070 * a4np_na)
parameters dlcn_na=1.012840e-07 + 0.0000e+000 * a1n_na
parameters cfn_na=1.350e-10 * (1 - 0.070 * a4np_na) + 3.57e-11 * ccoflag_na
parameters a1fn_na=4.529e+42
parameters a2fn_na=3.500e+23
parameters a3fn_na=1.510e+6
parameters b1fn_na=-6.730e+41
parameters b2fn_na=-1.535e+23
parameters b3fn_na=-5.855e+7
parameters c1fn_na=1.542e+42
parameters c2fn_na=4.400e+23
parameters c3fn_na=1.600e+6
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "cmn018_assp_v1d2.scs" section=mos_na
 
endsection sf_na
 
// *****************************   LIBRARY OF FNSP CORNER CASE   *******************************

section fs_na
include "cmn018_assp_v1d2.scs" section=setup_na
parameters parn1_na=0
parameters parn2_na=0
parameters a1n_na=-0.8
parameters a2n_na=0
parameters a3n_na=1
parameters a4np_na=0
parameters a5n_na=0
parameters toxn_na=3.986e-009 + 2.0000e-010 * a4np_na
parameters dxln_na=1.15e-008 * a2n_na
parameters dxwn_na=1.4e-008 * a3n_na
parameters dvth0n_na=0.0695 * a1n_na
parameters dlvth0n_na=4e-009 * a1n_na
parameters dwvth0n_na=2.4e-009 * a1n_na
parameters du0n_na=0.00395 * a1n_na
parameters dlu0n_na= - 1.8e-010 * a1n_na
parameters dpu0n_na= - 2.6e-016 * a1n_na
parameters dk2n_na=0 * a1n_na
parameters dwk2n_na=1.5e-009 * a1n_na
parameters dlvoffn_na=0
parameters dpvoffn_na=0
parameters cjn_na=9.81e-04 * (1 + 0.050 * a1n_na)
parameters cjswn_na=1.185e-10 * (1 + 0.100 * a1n_na)
parameters cjswgn_na=3.82667e-10 * (1 + 0.100 * a1n_na)
parameters cgon_na=7.508600e-12 * (1 - 0.070 * a4np_na)
parameters cgln_na=8.691250e-10 * (1 - 0.070 * a4np_na)
parameters dlcn_na=1.012840e-07 + 0.0000e+000 * a1n_na
parameters cfn_na=1.350e-10 * (1 - 0.070 * a4np_na) + 3.57e-11 * ccoflag_na
parameters a1fn_na=4.529e+42
parameters a2fn_na=3.500e+23
parameters a3fn_na=1.510e+6
parameters b1fn_na=-6.730e+41
parameters b2fn_na=-1.535e+23
parameters b3fn_na=-5.855e+7
parameters c1fn_na=1.542e+42
parameters c2fn_na=4.400e+23
parameters c3fn_na=1.600e+6
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "cmn018_assp_v1d2.scs" section=mos_na
 
endsection fs_na
 
// *********************************************************************************************
// **************************************************************
//                                                              *
//             3.3V Native VT  DEVICES LIB                      *  
//                                                              *
// **************************************************************
// *****************************     LIBRARY OF TYPICAL CASE     *******************************

section tt_3vna
include "cmn018_assp_v1d2.scs" section=setup_3vna
parameters parn1_3vna=0
parameters parn2_3vna=0
parameters toxn_3vna=6.693e-09
parameters dxln_3vna=0
parameters dxwn_3vna=0
parameters cjn_3vna=8.92000e-04
parameters cjswn_3vna=1.14000e-10
parameters cjswgn_3vna=2.71000e-10
parameters cgon_3vna=1.840590e-10
parameters cgln_3vna=1.515990e-10
parameters dlcn_3vna=6.556440e-08
parameters dvthn_3vna=0
parameters dlvthn_3vna=0
parameters dwvthn_3vna=0
parameters dpvthn_3vna=0
parameters du0n_3vna=0
parameters dlu0n_3vna=0
parameters dpu0n_3vna=0
parameters dk2n_3vna=0
parameters dwk2n_3vna=0
parameters dlvoffn_3vna=0
parameters dpvoffn_3vna=0
parameters cfn_3vna=1.360e-10 + 4.46e-11 * ccoflag_3vna
parameters a1fn_3vna=1.750e+41
parameters a2fn_3vna=1.115e+23
parameters a3fn_3vna=1.930e+8
parameters b1fn_3vna=-4.144e+40
parameters b2fn_3vna=-4.365e+22
parameters b3fn_3vna=-7.790e+7
parameters c1fn_3vna=9.230e+40
parameters c2fn_3vna=1.280e+23
parameters c3fn_3vna=2.320e+8
parameters noian_3vna=a1fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b1fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c1fn_3vna
parameters noibn_3vna=a2fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b2fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c2fn_3vna
parameters noicn_3vna=a3fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b3fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c3fn_3vna
include "cmn018_assp_v1d2.scs" section=mos_3vna
 
endsection tt_3vna
 
// *****************************   LIBRARY OF SNSP CORNER CASE   *******************************

section ss_3vna
include "cmn018_assp_v1d2.scs" section=setup_3vna
parameters parn1_3vna=0
parameters parn2_3vna=0
parameters toxn_3vna=6.893e-09
parameters dxln_3vna=1.15e-08
parameters dxwn_3vna=-1.40e-08
parameters cjn_3vna=8.92000e-04 * 1.05
parameters cjswn_3vna=1.14000e-10 * 1.1
parameters cjswgn_3vna=2.98100e-10
parameters cgon_3vna=1.71175e-10
parameters cgln_3vna=1.40987e-10
parameters dlcn_3vna=6.55644e-08
parameters dvthn_3vna=4.3e-02
parameters dlvthn_3vna=1.45e-08
parameters dwvthn_3vna=4.50e-09
parameters dpvthn_3vna=-0.8e-15
parameters du0n_3vna=-0.00315
parameters dlu0n_3vna=1.0e-9
parameters dpu0n_3vna=-1.26e-15
parameters dk2n_3vna=0.3e-2
parameters dwk2n_3vna=0.154e-8
parameters dlvoffn_3vna=0
parameters dpvoffn_3vna=0
parameters cfn_3vna=1.265e-10 + 4.46e-11 * ccoflag_3vna
parameters a1fn_3vna=1.750e+41
parameters a2fn_3vna=1.115e+23
parameters a3fn_3vna=1.930e+8
parameters b1fn_3vna=-4.144e+40
parameters b2fn_3vna=-4.365e+22
parameters b3fn_3vna=-7.790e+7
parameters c1fn_3vna=9.230e+40
parameters c2fn_3vna=1.280e+23
parameters c3fn_3vna=2.320e+8
parameters noian_3vna=a1fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b1fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c1fn_3vna
parameters noibn_3vna=a2fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b2fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c2fn_3vna
parameters noicn_3vna=a3fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b3fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c3fn_3vna
include "cmn018_assp_v1d2.scs" section=mos_3vna
 
endsection ss_3vna
 
// *****************************   LIBRARY OF FNFP CORNER CASE   *******************************

section ff_3vna
include "cmn018_assp_v1d2.scs" section=setup_3vna
parameters parn1_3vna=0
parameters parn2_3vna=0
parameters toxn_3vna=6.493e-09
parameters dxln_3vna=-1.15e-08
parameters dxwn_3vna=1.40e-08
parameters cjn_3vna=8.92000e-04 * 0.95
parameters cjswn_3vna=1.14000e-10 * 0.9
parameters cjswgn_3vna=2.43900e-10
parameters cgon_3vna=1.96943e-10
parameters cgln_3vna=1.62211e-10
parameters dlcn_3vna=6.55644e-08
parameters dvthn_3vna=-4.4e-02
parameters dlvthn_3vna=-1.4e-08
parameters dwvthn_3vna=-4.60e-09
parameters dpvthn_3vna=0.5e-15
parameters du0n_3vna=0.00295
parameters dlu0n_3vna=-1.45e-9
parameters dpu0n_3vna=0.93e-15
parameters dk2n_3vna=-0.3e-2
parameters dwk2n_3vna=-0.154e-8
parameters dlvoffn_3vna=0
parameters dpvoffn_3vna=0
parameters cfn_3vna=1.455e-10 + 4.46e-11 * ccoflag_3vna
parameters a1fn_3vna=1.750e+41
parameters a2fn_3vna=1.115e+23
parameters a3fn_3vna=1.930e+8
parameters b1fn_3vna=-4.144e+40
parameters b2fn_3vna=-4.365e+22
parameters b3fn_3vna=-7.790e+7
parameters c1fn_3vna=9.230e+40
parameters c2fn_3vna=1.280e+23
parameters c3fn_3vna=2.320e+8
parameters noian_3vna=a1fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b1fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c1fn_3vna
parameters noibn_3vna=a2fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b2fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c2fn_3vna
parameters noicn_3vna=a3fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b3fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c3fn_3vna
include "cmn018_assp_v1d2.scs" section=mos_3vna
 
endsection ff_3vna
 
// *****************************   LIBRARY OF SNFP CORNER CASE   *******************************

section sf_3vna
include "cmn018_assp_v1d2.scs" section=setup_3vna
parameters parn1_3vna=0
parameters parn2_3vna=0
parameters a1n_3vna=0.8
parameters a2n_3vna=0
parameters a3n_3vna=-1
parameters a4np_3vna=0
parameters a5n_3vna=0
parameters toxn_3vna=6.693e-09 + 2.0000e-010 * a4np_3vna
parameters dxln_3vna=1.15e-008 * a2n_3vna
parameters dxwn_3vna=1.4e-008 * a3n_3vna
parameters cjn_3vna=8.92000e-04 + 4.460e-005 * a1n_3vna
parameters cjswn_3vna=1.14000e-10 + 1.1400e-011 * a1n_3vna
parameters cjswgn_3vna=2.71000e-10 + 2.7100e-011 * a1n_3vna
parameters cgon_3vna=1.840590e-10 * (1 - 0.070 * a4np_3vna)
parameters cgln_3vna=1.515990e-10 * (1 - 0.070 * a4np_3vna)
parameters dlcn_3vna=6.556440e-08 + 0.0000e+000 * a1n_3vna
parameters dvthn_3vna=0.044 * a1n_3vna
parameters dlvthn_3vna=1.4e-008 * a1n_3vna
parameters dwvthn_3vna=4.6e-009 * a1n_3vna
parameters dpvthn_3vna= - 5e-016 * a1n_3vna
parameters du0n_3vna= - 0.00295 * a1n_3vna
parameters dlu0n_3vna=1.45e-009 * a1n_3vna
parameters dpu0n_3vna= - 9.3e-016 * a1n_3vna
parameters dk2n_3vna=0.003 * a1n_3vna
parameters dwk2n_3vna=1.54e-009 * a1n_3vna
parameters dlvoffn_3vna=0
parameters dpvoffn_3vna=0
parameters cfn_3vna=1.360e-10 * (1 - 0.070 * a4np_3vna) + 4.46e-11 * ccoflag_3vna
parameters a1fn_3vna=1.750e+41
parameters a2fn_3vna=1.115e+23
parameters a3fn_3vna=1.930e+8
parameters b1fn_3vna=-4.144e+40
parameters b2fn_3vna=-4.365e+22
parameters b3fn_3vna=-7.790e+7
parameters c1fn_3vna=9.230e+40
parameters c2fn_3vna=1.280e+23
parameters c3fn_3vna=2.320e+8
parameters noian_3vna=a1fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b1fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c1fn_3vna
parameters noibn_3vna=a2fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b2fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c2fn_3vna
parameters noicn_3vna=a3fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b3fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c3fn_3vna
include "cmn018_assp_v1d2.scs" section=mos_3vna
 
endsection sf_3vna
 
// *****************************   LIBRARY OF FNSP CORNER CASE   *******************************

section fs_3vna
include "cmn018_assp_v1d2.scs" section=setup_3vna
parameters parn1_3vna=0
parameters parn2_3vna=0
parameters a1n_3vna=-0.8
parameters a2n_3vna=0
parameters a3n_3vna=1
parameters a4np_3vna=0
parameters a5n_3vna=0
parameters toxn_3vna=6.693e-09 + 2.0000e-010 * a4np_3vna
parameters dxln_3vna=1.15e-008 * a2n_3vna
parameters dxwn_3vna=1.4e-008 * a3n_3vna
parameters cjn_3vna=8.92000e-04 + 4.460e-005 * a1n_3vna
parameters cjswn_3vna=1.14000e-10 + 1.1400e-011 * a1n_3vna
parameters cjswgn_3vna=2.71000e-10 + 2.7100e-011 * a1n_3vna
parameters cgon_3vna=1.840590e-10 * (1 - 0.070 * a4np_3vna)
parameters cgln_3vna=1.515990e-10 * (1 - 0.070 * a4np_3vna)
parameters dlcn_3vna=6.556440e-08 + 0.0000e+000 * a1n_3vna
parameters dvthn_3vna=0.044 * a1n_3vna
parameters dlvthn_3vna=1.4e-008 * a1n_3vna
parameters dwvthn_3vna=4.6e-009 * a1n_3vna
parameters dpvthn_3vna= - 5e-016 * a1n_3vna
parameters du0n_3vna= - 0.00295 * a1n_3vna
parameters dlu0n_3vna=1.45e-009 * a1n_3vna
parameters dpu0n_3vna= - 9.3e-016 * a1n_3vna
parameters dk2n_3vna=0.003 * a1n_3vna
parameters dwk2n_3vna=1.54e-009 * a1n_3vna
parameters dlvoffn_3vna=0
parameters dpvoffn_3vna=0
parameters cfn_3vna=1.360e-10 * (1 - 0.070 * a4np_3vna) + 4.46e-11 * ccoflag_3vna
parameters a1fn_3vna=1.750e+41
parameters a2fn_3vna=1.115e+23
parameters a3fn_3vna=1.930e+8
parameters b1fn_3vna=-4.144e+40
parameters b2fn_3vna=-4.365e+22
parameters b3fn_3vna=-7.790e+7
parameters c1fn_3vna=9.230e+40
parameters c2fn_3vna=1.280e+23
parameters c3fn_3vna=2.320e+8
parameters noian_3vna=a1fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b1fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c1fn_3vna
parameters noibn_3vna=a2fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b2fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c2fn_3vna
parameters noicn_3vna=a3fn_3vna * (abs(noiseflagn_3vna) + noiseflagn_3vna) + b3fn_3vna 
+ * (abs(noiseflagn_3vna) - noiseflagn_3vna) + c3fn_3vna
include "cmn018_assp_v1d2.scs" section=mos_3vna
 
endsection fs_3vna
 
// *********************************************************************************************
 

section mos
// *********************************************************************************************
 
// *********************************************************************************************
//                                                                            
//                   *
//                               1.8 V STD-SVT  NMOS DEVICE MODELS            
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt nch_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 xw= + 0 
+ + dxwn ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg + 
+ dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + (nf 
+ + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) * 
+ (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos 
+ temp1=parn1 temp2=parn2 fac1=0.621546 * temp1 * sigma + 0.783379 * temp2 * sigma 
+ fac2=0.621546 * temp1 * sigma - 0.783379 * temp2 * sigma lef=l * factor - 1.5e-08 
+ wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) vthmisn=0.00273276 
+ * geo_fac * fac1 * mismatchflag dlmisn=0.00176696 * geo_fac * lef * fac2 * mismatchflag 
+ dwmisn= - 0.00176696 * geo_fac * wef * fac2 * mismatchflag toxmisn=0.00176696 
+ * geo_fac * toxn * fac2 * mismatchflag 
nch_mac ( n1 n2 n3 n4 ) nch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nch bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln+dlmisn) lmax=2e-05                wmin=1.003e-005-(dxwn+dwmisn)
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln+dlmisn)
+ xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.43953+(dvthn+vthmisn)                        k1=0.448
+ k2=0.044342+dk2           k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0034927135
+ lkvth0we=0                wkvth0we=0                pkvth0we=0
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00082854+dcitn      voff=-0.13055+dvoffn      nfactor=0.94972
+ eta0=0.22771+deta0n       etab=-0.308               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.030526+du0n          ua=-1.1118e-009
+ ub=2.3263e-018            uc=1.9167e-010            vsat=73329+dvsatn
+ a0=1.0724+da0n            ags=0.50072               a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.051375            dwg=0                     dwb=0
+ pclm=0.71887+dpclmn       pdiblc1=0                 pdiblc2=0.000975+dpdiblc2n
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.24611586
+ kt1l=0                    kt2=-0.060191541          ute=-1.8116912
+ ua1=2.3415359e-009        ub1=-4.4298745e-018       uc1=-8.0699954e-011
+ prt=0                     at=67848.508              jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthn            wvth0=0+dwvthn
+ pvth0=0+dpvthn            lk2=0+dlk2                lcit=0+dlcitn
+ pcit=0+dpcitn             lvoff=0+dlvoffn           pvoff=0+dpvoffn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lu0=0+dlu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           pvsat=0+dpvsatn
+ la0=0+dla0n               pa0=0+dpa0n               lpclm=0+dlpclmn
+ ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n     ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.2e-006-(dxln+dlmisn)                         lmax=1e-005-(dxln+dlmisn)
+ wmin=1.003e-005-(dxwn+dwmisn)                       wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.44000255+(dvthn+vthmisn)
+ lvth0=-4.6939282e-009+dlvthn                        k1=0.448
+ k2=0.044420158+dk2        lk2=-7.763527e-010+dlk2   k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035080237      lkvth0we=-1.5207765e-010  wkvth0we=0
+ pkvth0we=0                k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00094159467+dcitn   lcit=-1.1229833e-009+dlcitn
+ voff=-0.13088478+dvoffn   lvoff=3.3253987e-009+dlvoffn
+ nfactor=0.94802421        lnfactor=1.6844423e-008   eta0=0.2200075+deta0n
+ leta0=7.650975e-008+dleta0n                         etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.031147016+du0n
+ lu0=-6.1686146e-009+dlu0n ua=-1.0351999e-009        lua=-7.608768e-016
+ ub=2.2622927e-018         lub=6.3579065e-025        uc=1.9814412e-010
+ luc=-6.4308095e-017       vsat=73219.038+dvsatn     lvsat=0.0010922656+dlvsatn
+ a0=1.0632966+da0n         la0=9.0425265e-008+dla0n  ags=0.47288051
+ lags=2.7653248e-007       a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.044517814
+ lketa=-6.8113118e-008     dwg=0                     dwb=0
+ pclm=0.73030143+dpclmn    lpclm=-1.1354958e-007+dlpclmn
+ pdiblc1=0                 pdiblc2=0.00083459861+dpdiblc2n
+ lpdiblc2=1.3946211e-009+dlpdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.24097779           lkt1=-5.1036979e-008
+ kt1l=0                    kt2=-0.061781821          lkt2=1.5796411e-008
+ ute=-1.8758               lute=6.3679863e-007       ua1=2.1882535e-009
+ lua1=1.5225695e-015       ub1=-4.4202733e-018       lub1=-9.5370005e-026
+ uc1=-9.4815908e-011       luc1=1.4021518e-016       prt=0
+ at=67632.492              lat=0.0021457058          jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 wvth0=0+dwvthn            pvth0=0+dpvthn
+ pcit=0+dpcitn             pvoff=0+dpvoffn           peta0=0+dpeta0n
+ pu0=0+dpu0n               pvsat=0+dpvsatn           pa0=0+dpa0n
+ ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n     fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     3: type=n 
+ lmin=5e-007-(dxln+dlmisn) lmax=1.2e-006-(dxln+dlmisn)
+ wmin=1.003e-005-(dxwn+dwmisn)                       wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.42487782+(dvthn+vthmisn)
+ lvth0=1.2443907e-008+dlvthn                         k1=0.448
+ k2=0.045638784+dk2        lk2=-2.1571775e-009+dlk2  k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0034998799      lkvth0we=-1.4284995e-010  wkvth0we=0
+ pkvth0we=0                k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00046662469+dcitn  lcit=4.7267005e-010+dlcitn
+ voff=-0.12040787+dvoffn   lvoff=-8.5459843e-009+dlvoffn
+ nfactor=1.0247614         lnfactor=-7.0106516e-008  eta0=0.28753+deta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.021368288+du0n       lu0=4.9116625e-009+dlu0n  ua=-2.2464725e-009
+ lua=6.1161625e-016        ub=3.3377372e-018         lub=-5.8279547e-025
+ uc=1.5619583e-010         luc=-1.6776489e-017       vsat=81168.284+dvsatn
+ lvsat=-0.0079150256+dlvsatn                         a0=1.6098828+da0n
+ la0=-5.289116e-007+dla0n  ags=0.84742922            lags=-1.4786866e-007
+ a1=0                      a2=0.995                  b0=0
+ b1=0                      keta=-0.11739531          lketa=1.4464376e-008
+ dwg=0                     dwb=0                     pclm=0.61209779+dpclmn
+ lpclm=2.0386975e-008+dlpclmn                        pdiblc1=0
+ pdiblc2=0.0024032799+dpdiblc2n                      lpdiblc2=-3.8285168e-010+dlpdiblc2n
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.28030251
+ lkt1=-6.4781365e-009      kt1l=0                    kt2=-0.050747054
+ lkt2=3.2929164e-009       ute=-1.3497898            lute=4.0776543e-008
+ ua1=3.8336541e-009        lua1=-3.4183397e-016      ub1=-5.1065691e-018
+ lub1=6.8227184e-025       uc1=3.805997e-013         luc1=3.2348021e-017
+ prt=0                     at=96010.896              lat=-0.030009864
+ jss=2.85e-07              jsd=2.85e-07              jsws=6.9e-13
+ jswd=6.9e-13              jswgs=6.9e-13             jswgd=6.9e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn                   cjd=cjn                   mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.202
+ mjswd=0.202               pbswgs=0.952              pbswgd=0.952
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.541
+ mjswgd=0.541              tpb=1.49e-3               tcj=9.05e-4
+ tpbsw=8.94e-04            tcjsw=8.09e-04            tpbswg=0.00133
+ tcjswg=0.00088            xtis=3                    xtid=3
+ jtsswgs=1.09e-009         jtsswgd=1.09e-009         njtsswg=11.6
+ xtsswgs=0.2886            xtsswgd=0.2886            tnjtsswg=1.08
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-3.2e-008
+ lku0=2e-007               wku0=7e-007               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 wvth0=0+dwvthn
+ pvth0=0+dpvthn            pcit=0+dpcitn             pvoff=0+dpvoffn
+ leta0=0+dleta0n           peta0=0+dpeta0n           pu0=0+dpu0n
+ pvsat=0+dpvsatn           pa0=0+dpa0n               ppclm=0+dppclmn
+ ppdiblc2=0+dppdiblc2n     fnoimod=1                 noia=noian
+ noib=noibn                noic=noicn                em=3.00e7
+ ef=0.904                  minr=1e-3
 
 
     4: type=n 
+ lmin=1.8e-07              lmax=5e-007-(dxln+dlmisn) wmin=1.003e-005-(dxwn+dwmisn)
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln+dlmisn)
+ xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.46146692+(dvthn+vthmisn)                     lvth0=-3.4028302e-009+dlvthn
+ k1=0.448                  k2=0.039663073+dk2        lk2=4.3090269e-010+dlk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.00349988        lkvth0we=-1.4284997e-010
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00061599596+dcitn
+ lcit=3.7870453e-012+dlcitn                          voff=-0.14584802+dvoffn
+ lvoff=2.4721416e-009+dlvoffn                        nfactor=0.78346906
+ lnfactor=3.4397209e-008   eta0=0.28753+deta0n       etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.030914951+du0n
+ lu0=7.7700251e-010+dlu0n  ua=-7.1464787e-010        lua=-5.1817006e-017
+ ub=1.5421034e-018         lub=1.9489354e-025        uc=7.8458172e-011
+ luc=1.6891692e-017        vsat=61073.15+dvsatn      lvsat=0.0007881769+dlvsatn
+ a0=0.20832912+da0n        la0=7.8101305e-008+dla0n  ags=0.31869166
+ lags=8.1127573e-008       a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.09467464
+ lketa=4.6240528e-009      dwg=0                     dwb=0
+ pclm=0.64898747+dpclmn    lpclm=4.4100556e-009+dlpclmn
+ pdiblc1=0                 pdiblc2=0.001415142+dpdiblc2n
+ lpdiblc2=4.5110843e-011+dlpdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.27298647           lkt1=-9.6467128e-009
+ kt1l=0                    kt2=-0.039573915          lkt2=-1.5461699e-009
+ ute=-1.2573881            lute=7.5736315e-010       ua1=2.9375154e-009
+ lua1=4.6283725e-017       ub1=-3.2787121e-018       lub1=-1.0937304e-025
+ uc1=7.8991529e-011        luc1=-1.6983721e-018      prt=0
+ at=27462.292              lat=-0.00032146321        jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 wvth0=0+dwvthn            pvth0=0+dpvthn
+ pcit=0+dpcitn             pvoff=0+dpvoffn           leta0=0+dleta0n
+ peta0=0+dpeta0n           pu0=0+dpu0n               pvsat=0+dpvsatn
+ pa0=0+dpa0n               ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     5: type=n 
+ lmin=1e-005-(dxln+dlmisn) lmax=2e-05                wmin=1.23e-006-(dxwn+dwmisn)
+ wmax=1.003e-005-(dxwn+dwmisn)                       version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxn+toxmisn)
+ toxm=(toxn+toxmisn)       dtox=5.958e-010           epsrox=3.9
+ wint=1.02e-008            lint=2.595e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.43767024+(dvthn+vthmisn)
+ wvth0=1.8615454e-008+dwvthn                         k1=0.448
+ k2=0.044105166+dk2        wk2=2.3706154e-009        k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0034939762      lkvth0we=0                wkvth0we=-1.2638696e-011
+ pkvth0we=0                k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00079963881+dcitn   wcit=2.8928938e-010
+ voff=-0.12992046+dvoffn   wvoff=-6.3014618e-009     nfactor=0.88693351
+ wnfactor=6.2846762e-007   eta0=0.21639887+deta0n    weta0=1.1321993e-007
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.02998869+du0n        wu0=5.3782564e-009        ua=-1.203133e-009
+ wua=9.1420727e-016        ub=2.4226144e-018         wub=-9.6406862e-025
+ uc=2.0880233e-010         wuc=-1.7148782e-016       vsat=73808.304+dvsatn
+ wvsat=-0.0047976413       a0=1.0648537+da0n         wa0=7.5534989e-008
+ ags=0.50587729            wags=-5.1622455e-008      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.053402592         wketa=2.0295385e-008      dwg=0
+ dwb=0                     pclm=0.72643962+dpclmn    wpclm=-7.5768887e-008
+ pdiblc1=0                 pdiblc2=0.00097154989+dpdiblc2n
+ wpdiblc2=3.4534212e-011   pdiblcb=0                 drout=0.5
+ pvag=0.6279               delta=0.005               pscbe1=4.5e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=90.88                 rdw=90.88
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.454e-007         alpha1=2.295              beta0=17.8
+ agidl=2.593e-009          bgidl=1.8508e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5.346                noff=1.973                voffcv=-0.0904
+ kt1=-0.24433236           wkt1=-1.7852096e-008      kt1l=0
+ kt2=-0.061344831          wkt2=1.1543968e-008       ute=-1.8450159
+ wute=3.3356664e-007       ua1=2.2889782e-009        wua1=5.2608194e-016
+ ub1=-4.4511878e-018       wub1=2.1333736e-025       uc1=-8.7610598e-011
+ wuc1=6.9172781e-017       prt=0                     at=64287.823
+ wat=0.035641033           jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1.00e-05            sbref=1.00e-05            wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthn            pvth0=0+dpvthn            lk2=0+dlk2
+ lcit=0+dlcitn             pcit=0+dpcitn             lvoff=0+dlvoffn
+ pvoff=0+dpvoffn           leta0=0+dleta0n           peta0=0+dpeta0n
+ lu0=0+dlu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ pvsat=0+dpvsatn           la0=0+dla0n               pa0=0+dpa0n
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n
+ ppdiblc2=0+dppdiblc2n     fnoimod=1                 noia=noian
+ noib=noibn                noic=noicn                em=3.00e7
+ ef=0.904                  minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-006-(dxln+dlmisn)                         lmax=1e-005-(dxln+dlmisn)
+ wmin=1.23e-006-(dxwn+dwmisn)                        wmax=1.003e-005-(dxwn+dwmisn)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.43826899+(dvthn+vthmisn)
+ lvth0=-5.9474128e-009+dlvthn                        wvth0=1.7352315e-008+dwvthn
+ pvth0=1.254688e-014+dpvthn                          k1=0.448
+ k2=0.044096635+dk2        lk2=8.473674e-011+dlk2    wk2=3.2383366e-009
+ pk2=-8.6191608e-015       k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035094668
+ lkvth0we=-1.5387034e-010  wkvth0we=-1.4445197e-011  pkvth0we=1.794415e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00091692734+dcitn   lcit=-1.1650387e-009+dlcitn
+ wcit=2.4691011e-010       pcit=4.2095749e-016+dpcitn
+ voff=-0.13043683+dvoffn   lvoff=5.1291508e-009+dlvoffn
+ wvoff=-4.4838181e-009     pvoff=-1.8054837e-014+dpvoffn
+ nfactor=0.88311971        lnfactor=3.7882923e-008   wnfactor=6.4966815e-007
+ pnfactor=-2.1058697e-013  eta0=0.20763762+deta0n    leta0=8.7026363e-008+dleta0n
+ weta0=1.2381754e-007      peta0=-1.0526709e-013+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030734961+du0n       lu0=-7.4127816e-009+dlu0n wu0=4.1245074e-009
+ pu0=1.2453614e-014+dpu0n  ua=-1.1100275e-009        lua=-9.2482661e-016
+ wua=7.489948e-016         pua=1.641072e-021         ub=2.3448197e-018
+ lub=7.727422e-025         wub=-8.2606234e-025       pub=-1.3708302e-030
+ uc=2.1675785e-010         luc=-7.9022914e-017       wuc=-1.8631596e-016
+ puc=1.4728946e-022        vsat=73706.519+dvsatn     lvsat=0.001011044+dlvsatn
+ wvsat=-0.0048794884       pvsat=8.1299557e-010+dpvsatn
+ a0=1.0494623+da0n         la0=1.5288501e-007+dla0n  wa0=1.3847577e-007
+ pa0=-6.2519711e-013+dpa0n ags=0.48226057            lags=2.3458734e-007
+ wags=-9.3890644e-008      pags=4.1985414e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.046062599         lketa=-7.2908884e-008     wketa=1.5462685e-008
+ pketa=4.8003693e-014      dwg=0                     dwb=0
+ pclm=0.73944236+dpclmn    lpclm=-1.2915748e-007+dlpclmn
+ wpclm=-9.1496997e-008     ppclm=1.5622889e-013+dppclmn
+ pdiblc1=0                 pdiblc2=0.00082255572+dpdiblc2n
+ lpdiblc2=1.479974e-009+dlpdiblc2n                   wpdiblc2=1.2054455e-010
+ ppdiblc2=-8.5434924e-016+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.23907403           lkt1=-5.2231546e-008
+ wkt1=-1.9055864e-008      pkt1=1.1957141e-014       kt1l=0
+ kt2=-0.063097929          lkt2=1.7413704e-008       wkt2=1.3173717e-008
+ pkt2=-1.6188456e-014      ute=-1.9123217            lute=6.6855562e-007
+ wute=3.6556821e-007       pute=-3.1787476e-013      ua1=2.1228227e-009
+ lua1=1.6504387e-015       wua1=6.5493592e-016       pua1=-1.2799195e-021
+ ub1=-4.4301109e-018       lub1=-2.0935864e-025      wub1=9.8470839e-026
+ pub1=1.1409807e-030       uc1=-1.0240556e-010       luc1=1.4695986e-016
+ wuc1=7.5969403e-017       puc1=-6.7511529e-023      prt=0
+ at=63802.066              lat=0.0048250702          wat=0.038341033
+ pat=-2.6819365e-008       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     7: type=n 
+ lmin=5e-007-(dxln+dlmisn) lmax=1.2e-006-(dxln+dlmisn)
+ wmin=1.23e-006-(dxwn+dwmisn)                        wmax=1.003e-005-(dxwn+dwmisn)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.42037368+(dvthn+vthmisn)
+ lvth0=1.4329762e-008+dlvthn                         wvth0=4.5084673e-008+dwvthn
+ pvth0=-1.8876655e-014+dpvthn                        k1=0.448
+ k2=0.046221224+dk2        lk2=-2.3226355e-009+dlk2  wk2=-5.8299975e-009
+ pk2=1.6561685e-015        k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035012271
+ lkvth0we=-1.4453387e-010  wkvth0we=-1.3484334e-011  pkvth0we=1.6855396e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00058574619+dcitn  lcit=5.3764069e-010+dlcitn
+ wcit=1.1923586e-009       pcit=-6.5033018e-016+dpcitn
+ voff=-0.11697501+dvoffn   lvoff=-1.0124436e-008+dlvoffn
+ wvoff=-3.4361596e-008     pvoff=1.5799673e-014+dpvoffn
+ nfactor=0.97842413        lnfactor=-7.0106516e-008  wnfactor=4.6381786e-007
+ pnfactor=-3.6153196e-028  eta0=0.2857596+deta0n     leta0=-1.4936512e-009+dleta0n
+ weta0=1.7721043e-008      peta0=1.4950851e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.018994069+du0n       lu0=5.8908231e-009+dlu0n  wu0=2.3764981e-008
+ pu0=-9.8010062e-015+dpu0n ua=-2.5857121e-009        lua=7.4727158e-016
+ wua=3.3956523e-015        pua=-1.3578556e-021       ub=3.6579891e-018
+ lub=-7.1521005e-025       wub=-3.2055939e-024       pub=1.325417e-030
+ uc=1.6778828e-010         luc=-2.3535502e-017       wuc=-1.1603581e-016
+ puc=6.7655012e-023        vsat=82472.125+dvsatn     lvsat=-0.0089212647+dlvsatn
+ wvsat=-0.013050925        pvsat=1.0072051e-008+dpvsatn
+ a0=1.7153328+da0n         la0=-6.016129e-007+dla0n  wa0=-1.0555125e-006
+ pa0=7.2771096e-013+dpa0n  ags=0.8525523             lags=-1.8499023e-007
+ wags=-5.1280026e-008      pags=3.7157205e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.12659406          lketa=1.8341317e-008      wketa=9.2075794e-008
+ pketa=-3.8806621e-014     dwg=0                     dwb=0
+ pclm=0.60499108+dpclmn    lpclm=2.3189257e-008+dlpclmn
+ wpclm=7.1135264e-008      ppclm=-2.8049725e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0025232125+dpdiblc2n
+ lpdiblc2=-4.4704014e-010+dlpdiblc2n                 wpdiblc2=-1.2004774e-009
+ ppdiblc2=6.4250076e-016+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.28058066           lkt1=-5.2003825e-009
+ wkt1=2.7841751e-009       pkt1=-1.2789807e-014      kt1l=0
+ kt2=-0.051128002          lkt2=3.8505801e-009       wkt2=3.8131443e-009
+ pkt2=-5.5819908e-015      ute=-1.3645922            lute=4.7923298e-008
+ wute=1.4816586e-007       pute=-7.1536156e-014      ua1=3.9108885e-009
+ lua1=-3.7561866e-016      wua1=-7.7308516e-016      pua1=3.3817117e-022
+ ub1=-5.2851432e-018       lub1=7.594785e-025        wub1=1.7874554e-024
+ pub1=-7.7280775e-031      uc1=-4.4561452e-012       luc1=3.5973378e-017
+ wuc1=4.8413882e-017       puc1=-3.6288368e-023      prt=0
+ at=93916.287              lat=-0.029297354          wat=0.020966199
+ pat=-7.1319407e-009       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     8: type=n 
+ lmin=1.8e-07              lmax=5e-007-(dxln+dlmisn) wmin=1.23e-006-(dxwn+dwmisn)
+ wmax=1.003e-005-(dxwn+dwmisn)                       version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxn+toxmisn)
+ toxm=(toxn+toxmisn)       dtox=5.958e-010           epsrox=3.9
+ wint=1.02e-008            lint=2.595e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.46153716+(dvthn+vthmisn)
+ lvth0=-3.4981445e-009+dlvthn                        wvth0=-7.0316591e-010+dwvthn
+ pvth0=9.5405814e-016+dpvthn                         k1=0.448
+ k2=0.04005708+dk2         lk2=3.4705556e-010+dlk2   wk2=-3.9438461e-009
+ pk2=8.3927631e-016        k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035012271
+ lkvth0we=-1.4453389e-010  wkvth0we=-1.3484357e-011  pkvth0we=1.6855406e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00063596926+dcitn   lcit=8.5157293e-012+dlcitn
+ wcit=-1.9992482e-010      pcit=-4.7332235e-017+dpcitn
+ voff=-0.14662081+dvoffn   lvoff=2.7151615e-009+dlvoffn
+ wvoff=7.7353926e-009      pvoff=-2.4325323e-015+dpvoffn
+ nfactor=0.72621499        lnfactor=3.9125262e-008   wnfactor=5.7309035e-007
+ pnfactor=-4.7325917e-014  eta0=0.28035301+deta0n    leta0=8.4793969e-010+dleta0n
+ weta0=7.1838771e-008      peta0=-8.4875371e-015+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030600569+du0n       lu0=8.6404784e-010+dlu0n  wu0=3.1468385e-009
+ pu0=-8.7128886e-016+dpu0n ua=-7.360552e-010         lua=-5.3814819e-017
+ wua=2.1427874e-016        pua=1.9997311e-023        ub=1.5214649e-018
+ lub=2.1011858e-025        wub=2.0658252e-025        pub=-1.5239657e-031
+ uc=7.1563125e-011         luc=1.8139615e-017        wuc=6.9016661e-017
+ puc=-1.2491212e-023       vsat=59837.656+dvsatn     lvsat=0.00088172379+dlvsatn
+ wvsat=0.012366802         pvsat=-9.36367e-010+dpvsatn
+ a0=0.12876526+da0n        la0=8.5529509e-008+dla0n  wa0=7.9640237e-007
+ pa0=-7.4353352e-014+dpa0n ags=0.19374941            lags=1.003373e-007
+ wags=1.2506219e-006       pags=-1.9228168e-013      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.094572384         lketa=4.4727282e-009      wketa=-1.0235369e-009
+ pketa=1.5146989e-015      dwg=0                     dwb=0
+ pclm=0.64375475+dpclmn    lpclm=6.400715e-009+dlpclmn
+ wpclm=5.2377423e-008      ppclm=-1.9925704e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0013400495+dpdiblc2n
+ lpdiblc2=6.5387753e-011+dlpdiblc2n                  wpdiblc2=7.5164568e-010
+ ppdiblc2=-2.0296376e-016+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.26854017           lkt1=-1.0415119e-008
+ wkt1=-4.4505704e-008      pkt1=7.6914398e-015       kt1l=0
+ kt2=-0.038022537          lkt2=-1.825397e-009       wkt2=-1.5528675e-008
+ pkt2=2.7949512e-015       ute=-1.2578727            lute=1.7030936e-009
+ wute=4.8507534e-009       pute=-9.4663839e-015      ua1=2.9101028e-009
+ lua1=5.7821643e-017       wua1=2.7438913e-016       pua1=-1.1548994e-022
+ ub1=-3.2377504e-018       lub1=-1.2724735e-025      wub1=-4.1001048e-025
+ pub1=1.7891473e-031       uc1=8.2624854e-011        luc1=-1.7414029e-018
+ wuc1=-3.6368127e-017      puc1=4.3072039e-025       prt=0
+ at=26853.963              lat=-0.00025266125        wat=0.0060891249
+ pat=-6.8868002e-010       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     9: type=n 
+ lmin=1e-005-(dxln+dlmisn) lmax=2e-05                wmin=5.3e-007-(dxwn+dwmisn)
+ wmax=1.23e-006-(dxwn+dwmisn)                        version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxn+toxmisn)
+ toxm=(toxn+toxmisn)       dtox=5.958e-010           epsrox=3.9
+ wint=1.02e-008            lint=2.595e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.45091968+(dvthn+vthmisn)
+ wvth0=2.5889311e-009+dwvthn                         k1=0.448
+ k2=0.049658408+dk2        wk2=-4.3465863e-009       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.003492826       lkvth0we=0                wkvth0we=-1.1247497e-011
+ pkvth0we=0                k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0011644892+dcitn    wcit=-1.5203366e-010
+ voff=-0.12502536+dvoffn   wvoff=-1.2222573e-008     nfactor=1.3196496
+ wnfactor=1.0505424e-007   eta0=0.38866768+deta0n    weta0=-9.5156426e-008
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.037683336+du0n       wu0=-3.9291872e-009       ua=-2.803732e-010
+ wua=-2.0196304e-016       ub=1.6975264e-018         wub=-8.7002173e-026
+ uc=5.6835816e-011         wuc=1.2330885e-017        vsat=56060.96+dvsatn
+ wvsat=0.016669546         a0=1.2341704+da0n         wa0=-1.2927044e-007
+ ags=0.49009232            wags=-3.252895e-008       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.02910376          wketa=-9.0964823e-009     dwg=0
+ dwb=0                     pclm=0.6638+dpclmn        pdiblc1=0
+ pdiblc2=0.001072536+dpdiblc2n                       wpdiblc2=-8.7618586e-011
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=6.8                   rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.26270789
+ wkt1=4.3749413e-009       kt1l=0                    kt2=-0.055266569
+ wkt2=4.1917031e-009       ute=-1.6297245            wute=7.3150159e-008
+ ua1=2.9265549e-009        wua1=-2.4513091e-016      ub1=-4.6663733e-018
+ wub1=4.7362574e-025       uc1=-1.5828853e-011       wuc1=-1.7654419e-017
+ prt=0                     at=97530.221              wat=-0.0045689711
+ jss=2.85e-07              jsd=2.85e-07              jsws=6.9e-13
+ jswd=6.9e-13              jswgs=6.9e-13             jswgd=6.9e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn                   cjd=cjn                   mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.202
+ mjswd=0.202               pbswgs=0.952              pbswgd=0.952
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.541
+ mjswgd=0.541              tpb=1.49e-3               tcj=9.05e-4
+ tpbsw=8.94e-04            tcjsw=8.09e-04            tpbswg=0.00133
+ tcjswg=0.00088            xtis=3                    xtid=3
+ jtsswgs=1.09e-009         jtsswgd=1.09e-009         njtsswg=11.6
+ xtsswgs=0.2886            xtsswgd=0.2886            tnjtsswg=1.08
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.00e-05
+ sbref=1.00e-05            wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-3.2e-008
+ lku0=2e-007               wku0=7e-007               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 lvth0=0+dlvthn
+ pvth0=0+dpvthn            lk2=0+dlk2                lcit=0+dlcitn
+ pcit=0+dpcitn             lvoff=0+dlvoffn           pvoff=0+dpvoffn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lu0=0+dlu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           pvsat=0+dpvsatn
+ la0=0+dla0n               pa0=0+dpa0n               lpclm=0+dlpclmn
+ ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n     ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     10: type=n 
+ lmin=1.2e-006-(dxln+dlmisn)                         lmax=1e-005-(dxln+dlmisn)
+ wmin=5.3e-007-(dxwn+dwmisn)                         wmax=1.23e-006-(dxwn+dwmisn)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.45009359+(dvthn+vthmisn)
+ lvth0=8.2056515e-009+dlvthn                         wvth0=3.0492775e-009+dwvthn
+ pvth0=-4.5726669e-015+dpvthn                        k1=0.448
+ k2=0.0506837+dk2          lk2=-1.0184325e-008+dlk2  wk2=-4.7293768e-009
+ pk2=3.8022964e-015        k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035081523
+ lkvth0we=-1.5223742e-010  wkvth0we=-1.2855149e-011  pkvth0we=1.5968969e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0012816735+dcitn    lcit=-1.1640036e-009+dlcitn
+ wcit=-1.9428688e-010      pcit=4.197055e-016+dpcitn voff=-0.12390125+dvoffn
+ lvoff=-1.116587e-008+dlvoffn                        wvoff=-1.238925e-008
+ pvoff=1.6556208e-015+dpvoffn                        nfactor=1.3034321
+ lnfactor=1.610905e-007    wnfactor=1.4125833e-007   pnfactor=-3.5961885e-013
+ eta0=0.38567368+deta0n    leta0=2.9739706e-008+dleta0n
+ weta0=-9.1534883e-008     peta0=-3.5973148e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.037135421+du0n       lu0=5.4424908e-009+dlu0n  wu0=-3.6174896e-009
+ pu0=-3.0961235e-015+dpu0n ua=-3.4387548e-010        lua=6.3077452e-016
+ wua=-1.777427e-016        pua=-2.405831e-022        ub=1.7416045e-018
+ lub=-4.3783223e-025       wub=-9.6413196e-026       pub=9.3480629e-032
+ uc=5.2319544e-011         luc=4.486058e-017         wuc=1.2588611e-017
+ puc=-2.5600177e-024       vsat=54415.882+dvsatn     lvsat=0.016340723+dlvsatn
+ wvsat=0.018454465         pvsat=-1.7729784e-008+dpvsatn
+ a0=1.2658264+da0n         la0=-3.1444254e-007+dla0n wa0=-1.2323831e-007
+ pa0=-5.9917704e-014+dpa0n ags=0.42466814            lags=6.4986497e-007
+ wags=-2.4226841e-008      pags=-8.2465682e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.02494072          lketa=-4.1351896e-008     wketa=-1.008634e-008
+ pketa=9.8323601e-015      dwg=0                     dwb=0
+ pclm=0.6638+dpclmn        pdiblc1=0                 pdiblc2=0.0010118305+dpdiblc2n
+ lpdiblc2=6.0299404e-010+dlpdiblc2n                  wpdiblc2=-1.0840221e-010
+ ppdiblc2=2.0644577e-016+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.25901356           lkt1=-3.6696172e-008
+ wkt1=5.0629891e-009       pkt1=-6.8344476e-015      kt1l=0
+ kt2=-0.056213203          lkt2=9.4030112e-009       wkt2=4.8459522e-009
+ pkt2=-6.4987215e-015      ute=-1.676861             lute=4.6821162e-007
+ wute=8.0754901e-008       pute=-7.5538655e-014      ua1=2.8875828e-009
+ lua1=3.871136e-016        wua1=-2.7011793e-016      pua1=2.481985e-022
+ ub1=-4.7956442e-018       lub1=1.2840609e-024       wub1=5.4061989e-025
+ pub1=-6.6545954e-031      uc1=-2.6953883e-011       luc1=1.1050604e-016
+ wuc1=-1.5296949e-017      puc1=-2.3416982e-023      prt=0
+ at=100664.73              lat=-0.031135429          wat=-0.0062480496
+ pat=1.6678455e-008        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     11: type=n 
+ lmin=5e-007-(dxln+dlmisn) lmax=1.2e-006-(dxln+dlmisn)
+ wmin=5.3e-007-(dxwn+dwmisn)                         wmax=1.23e-006-(dxwn+dwmisn)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.46386651+(dvthn+vthmisn)
+ lvth0=-7.4004438e-009+dlvthn                        wvth0=-7.5242539e-009+dwvthn
+ pvth0=7.4082015e-015+dpvthn                         k1=0.448
+ k2=0.041798436+dk2        lk2=-1.164329e-010+dlk2   wk2=-4.8019262e-010
+ pk2=-1.0124542e-015       k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0034999999
+ lkvth0we=-1.4299998e-010  wkvth0we=-1.2000002e-011  pkvth0we=1.5000003e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0002093576+dcitn    lcit=5.1037543e-011+dlcitn
+ wcit=2.3060105e-010       pcit=-6.1735013e-017+dpcitn
+ voff=-0.14158636+dvoffn   lvoff=8.8731293e-009+dlvoffn
+ wvoff=-4.5917007e-009     pvoff=-7.179782e-015+dpvoffn
+ nfactor=1.5074714         lnfactor=-7.0106516e-008  wnfactor=-1.7611776e-007
+ pnfactor=-8.4625901e-029  eta0=0.444895+deta0n      leta0=-3.7363969e-008+dleta0n
+ weta0=-1.7476914e-007     peta0=5.8339587e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.047238653+du0n       lu0=-6.0054812e-009+dlu0n wu0=-1.0399669e-008
+ pu0=4.5887635e-015+dpu0n  ua=7.1915788e-010         lua=-5.7374858e-016
+ wua=-6.0191843e-016       pua=2.4005042e-022        ub=1.1708869e-018
+ lub=2.0884787e-025        wub=-1.9719508e-025       pub=2.0767658e-031
+ uc=6.3459404e-011         luc=3.2238005e-017        wuc=1.0160408e-017
+ puc=1.9137854e-025        vsat=72259.383+dvsatn     lvsat=-0.0038777484+dlvsatn
+ wvsat=-0.00069759276      pvsat=3.9714134e-009+dpvsatn
+ a0=1.1074481+da0n         la0=-1.3498409e-007+dla0n wa0=-3.2021516e-007
+ pa0=1.6327676e-013+dpa0n  ags=1.0257791             lags=-3.1253821e-008
+ wags=-2.6081511e-007      pags=1.8561249e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.044894245         lketa=-1.8742556e-008     wketa=-6.7483042e-009
+ pketa=6.0500312e-015      dwg=0                     dwb=0
+ pclm=0.74766895+dpclmn    lpclm=-9.5031906e-008+dlpclmn
+ wpclm=-1.0144788e-007     ppclm=1.1495059e-013+dppclmn
+ pdiblc1=0                 pdiblc2=0.0014356508+dpdiblc2n
+ lpdiblc2=1.2276324e-010+dlpdiblc2n                  wpdiblc2=1.1503719e-010
+ ppdiblc2=-4.6733404e-017+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.26914528           lkt1=-2.5215912e-008
+ wkt1=-1.1048056e-008      pkt1=1.1420977e-014       kt1l=0
+ kt2=-0.046010664          lkt2=-2.157486e-009       wkt2=-2.3767884e-009
+ pkt2=1.6853658e-015       ute=-1.2217685            lute=-4.7453698e-008
+ wute=-2.4593713e-008      pute=4.3831859e-014       ua1=3.2126425e-009
+ lua1=1.8788546e-017       wua1=7.1513245e-017       pua1=-1.3890378e-022
+ ub1=-3.4530876e-018       lub1=-2.3718997e-025      wub1=-4.2859905e-025
+ pub1=4.3276244e-031       uc1=9.385696e-011         luc1=-2.6384728e-017
+ wuc1=-7.050565e-017       puc1=3.9139997e-023       prt=0
+ at=101453.47              lat=-0.032029141          wat=0.011849228
+ pat=-3.8275708e-009       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
     12: type=n 
+ lmin=1.8e-07              lmax=5e-007-(dxln+dlmisn) wmin=5.3e-007-(dxwn+dwmisn)
+ wmax=1.23e-006-(dxwn+dwmisn)                        version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxn+toxmisn)
+ toxm=(toxn+toxmisn)       dtox=5.958e-010           epsrox=3.9
+ wint=1.02e-008            lint=2.595e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.45100766+(dvthn+vthmisn)
+ lvth0=-1.8312768e-009+dlvthn                        wvth0=1.2033323e-008+dwvthn
+ pvth0=-1.0621851e-015+dpvthn                        k1=0.448
+ k2=0.038163914+dk2        lk2=1.4576788e-009+dlk2   wk2=-1.6538724e-009
+ pk2=-5.0413351e-016       k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035
+ lkvth0we=-1.4299999e-010  wkvth0we=-1.1999982e-011  pkvth0we=1.4999994e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.000449348+dcitn     lcit=-5.2902299e-011+dlcitn
+ wcit=2.5812259e-011       pcit=2.6959011e-017+dpcitn
+ voff=-0.12170577+dvoffn   lvoff=2.6284605e-010+dlvoffn
+ wvoff=-2.2401838e-008     pvoff=5.3378843e-016+dpvoffn
+ nfactor=1.3456            wnfactor=-1.7611776e-007  eta0=0.34772908+deta0n
+ leta0=4.7185912e-009+dleta0n                        weta0=-9.6593161e-009
+ peta0=-1.3169477e-014+dpeta0n                       etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.03277883+du0n
+ lu0=2.5706843e-010+dlu0n  wu0=5.1201478e-010        pu0=-1.3708657e-016+dpu0n
+ ua=-4.8910711e-010        lua=-5.0449016e-017       wua=-8.4429657e-017
+ pua=1.5926036e-023        ub=1.3163084e-018         lub=1.4586584e-025
+ wub=4.5473991e-025        pub=-7.4676462e-032       uc=1.0368654e-010
+ luc=1.4815632e-017        wuc=3.0160177e-017        puc=-8.4705214e-024
+ vsat=61090.882+dvsatn     lvsat=0.00095932931+dlvsatn
+ wvsat=0.010850899         pvsat=-1.0302386e-009+dpvsatn
+ a0=0.75505102+da0n        la0=1.7639096e-008+dla0n  wa0=3.8847114e-008
+ pa0=7.7668912e-015+dpa0n  ags=1.0232614             lags=-3.0163421e-008
+ wags=2.4724421e-007       pags=-3.4428006e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.10179985          lketa=5.9032598e-009      wketa=7.7188011e-009
+ pketa=-2.1567209e-016     dwg=0                     dwb=0
+ pclm=0.56941084+dpclmn    lpclm=-1.782832e-008+dlpclmn
+ wpclm=1.4230381e-007      ppclm=9.381736e-015+dppclmn
+ pdiblc1=0                 pdiblc2=0.0020754301+dpdiblc2n
+ lpdiblc2=-1.5432519e-010+dlpdiblc2n                 wpdiblc2=-1.3787073e-010
+ ppdiblc2=6.2801017e-017+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.31710055           lkt1=-4.4464872e-009
+ wkt1=1.4232929e-008       pkt1=4.717827e-016        kt1l=0
+ kt2=-0.052717218          lkt2=7.4712251e-010       wkt2=2.2460105e-009
+ pkt2=-3.1676838e-016      ute=-1.3166839            lute=-6.3458267e-009
+ wute=7.5988759e-008       pute=2.6959011e-016       ua1=3.2603755e-009
+ lua1=-1.8846444e-018      wua1=-1.493008e-016       pua1=-4.3269213e-023
+ ub1=-3.9051406e-018       lub1=-4.1405846e-026      wub1=3.972647e-025
+ pub1=7.5080847e-032       uc1=4.9651032e-011        luc1=-7.239141e-018
+ wuc1=3.5170072e-018       puc1=7.0807845e-024       prt=0
+ at=28649.452              lat=-0.00049772277        wat=0.003917302
+ pat=-3.9225362e-010       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     13: type=n 
+ lmin=1e-005-(dxln+dlmisn) lmax=2e-05                wmin=2.2e-07
+ wmax=5.3e-007-(dxwn+dwmisn)                         version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxn+toxmisn)
+ toxm=(toxn+toxmisn)       dtox=5.958e-010           epsrox=3.9
+ wint=1.02e-008            lint=2.595e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.45303175+(dvthn+vthmisn)
+ wvth0=1.5126177e-009+dwvthn                         k1=0.448
+ k2=0.049498679+dk2        wk2=-4.2651883e-009       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.003492826       lkvth0we=0                wkvth0we=-1.1247478e-011
+ pkvth0we=0                k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00089942525+dcitn   wcit=-1.6957068e-011
+ voff=-0.14737457+dvoffn   wvoff=-8.3341628e-010     nfactor=1.658695
+ wnfactor=-6.7723276e-008  eta0=0.17743427+deta0n    weta0=1.248812e-008
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.025695765+du0n       wu0=2.1796789e-009        ua=-7.1525143e-010
+ wua=1.9650906e-017        ub=9.9908335e-019         wub=2.689244e-025
+ uc=6.9611373e-011         wuc=5.8204612e-018        vsat=101331.99+dvsatn
+ wvsat=-0.0064005714       a0=0.96639923+da0n        wa0=7.1857545e-009
+ ags=0.29637191            wags=6.6190971e-008       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.061694138         wketa=7.5115744e-009      dwg=0
+ dwb=0                     pclm=0.69121603+dpclmn    wpclm=-1.3971207e-008
+ pdiblc1=0                 pdiblc2=0.00058465252+dpdiblc2n
+ wpdiblc2=1.6100684e-010   pdiblcb=0                 drout=0.5
+ pvag=0.6279               delta=0.005               pscbe1=4.5e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=6.8
+ rdsw=200                  rsw=90.88                 rdw=90.88
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.454e-007         alpha1=2.295              beta0=17.8
+ agidl=2.593e-009          bgidl=1.8508e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5.346                noff=1.973                voffcv=-0.0904
+ kt1=-0.26006509           wkt1=3.0281688e-009       kt1l=0
+ kt2=-0.054118684          wkt2=3.6067408e-009       ute=-1.4386321
+ wute=-2.4230528e-008      ua1=2.9965633e-009        wua1=-2.8080718e-016
+ ub1=-4.2139758e-018       wub1=2.4308397e-025       uc1=-3.0422229e-011
+ wuc1=-1.0217634e-017      prt=0                     at=55390.665
+ wat=0.016905347           jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1.00e-05            sbref=1.00e-05            wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthn            pvth0=0+dpvthn            lk2=0+dlk2
+ lcit=0+dlcitn             pcit=0+dpcitn             lvoff=0+dlvoffn
+ pvoff=0+dpvoffn           leta0=0+dleta0n           peta0=0+dpeta0n
+ lu0=0+dlu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ pvsat=0+dpvsatn           la0=0+dla0n               pa0=0+dpa0n
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n
+ ppdiblc2=0+dppdiblc2n     fnoimod=1                 noia=noian
+ noib=noibn                noic=noicn                em=3.00e7
+ ef=0.904                  minr=1e-3
 
 
     14: type=n 
+ lmin=1.2e-006-(dxln+dlmisn)                         lmax=1e-005-(dxln+dlmisn)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwn+dwmisn)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.45234877+(dvthn+vthmisn)
+ lvth0=6.7841929e-009+dlvthn                         wvth0=1.9000387e-009+dwvthn
+ pvth0=-3.8482916e-015+dpvthn                        k1=0.448
+ k2=0.049708891+dk2        lk2=-2.0880632e-009+dlk2  wk2=-4.2326145e-009
+ pk2=-3.2355865e-016       k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035081523
+ lkvth0we=-1.5223736e-010  wkvth0we=-1.2855127e-011  pkvth0we=1.5968941e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00093598992+dcitn   lcit=-3.6320049e-010+dlcitn
+ wcit=-1.8126514e-011      pcit=1.1616217e-017+dpcitn
+ voff=-0.14627576+dvoffn   lvoff=-1.0914586e-008+dlvoffn
+ wvoff=-9.8720172e-010     pvoff=1.5275661e-015+dpvoffn
+ nfactor=1.7223427         lnfactor=-6.3221952e-007  wnfactor=-7.2218542e-008
+ pnfactor=4.4651933e-014   eta0=0.18419492+deta0n    leta0=-6.7154174e-008+dleta0n
+ weta0=1.1138695e-008      peta0=1.3403973e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.025734547+du0n       lu0=-3.8522805e-010+dlu0n wu0=2.1923957e-009
+ pu0=-1.2631797e-016+dpu0n ua=-7.4834311e-010        lua=3.2870292e-016
+ wua=2.8374005e-017        pua=-8.6647412e-023       ub=1.0002368e-018
+ lub=-1.145736e-026        wub=2.8138778e-025        pub=-1.238e-031
+ uc=6.3534915e-011         luc=6.0358059e-017        wuc=6.8732577e-018
+ puc=-1.0457533e-023       vsat=104447.26+dvsatn     lvsat=-0.030944327+dlvsatn
+ wvsat=-0.0070415271       pvsat=6.3666774e-009+dpvsatn
+ a0=1.0509621+da0n         la0=-8.3997116e-007+dla0n wa0=-1.374343e-008
+ pa0=2.0789168e-013+dpa0n  ags=0.23996998            lags=5.6024604e-007
+ wags=6.9895341e-008       pags=-3.6795879e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.061786008         lketa=9.1255707e-010      wketa=8.6900186e-009
+ pketa=-1.1705605e-014     dwg=0                     dwb=0
+ pclm=0.69474615+dpclmn    lpclm=-3.5065083e-008+dlpclmn
+ wpclm=-1.5770158e-008     ppclm=1.7869166e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0004881786+dpdiblc2n
+ lpdiblc2=9.5828501e-010+dlpdiblc2n                  wpdiblc2=1.5845079e-010
+ ppdiblc2=2.5389492e-017+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.25492349           lkt1=-5.1071948e-008
+ wkt1=2.978693e-009        pkt1=4.9144824e-016       kt1l=0
+ kt2=-0.054481381          lkt2=3.6027024e-009       wkt2=3.9634154e-009
+ pkt2=-3.5428841e-015      ute=-1.4614899            lute=2.270494e-007
+ wute=-2.8998185e-008      pute=4.7357614e-014       ua1=2.9533953e-009
+ lua1=4.2879233e-016       wua1=-3.0365594e-016      pua1=2.2695902e-022
+ ub1=-4.2552952e-018       lub1=4.1043047e-025       wub1=2.6525806e-025
+ pub1=-2.2025749e-031      uc1=-3.4311091e-011       luc1=3.8628462e-017
+ wuc1=-1.1547715e-017      puc1=1.321183e-023        prt=0
+ at=49816.344              lat=0.055370285           wat=0.01966429
+ pat=-2.7404857e-008       jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     15: type=n 
+ lmin=5e-007-(dxln+dlmisn) lmax=1.2e-006-(dxln+dlmisn)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwn+dwmisn)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn+toxmisn)       toxm=(toxn+toxmisn)       dtox=5.958e-010
+ epsrox=3.9                wint=1.02e-008            lint=2.595e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)
+ dlc=2.595e-008+dlcn       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.44828089+(dvthn+vthmisn)
+ lvth0=1.1393503e-008+dlvthn                         wvth0=4.181767e-010+dwvthn
+ pvth0=-2.1691937e-015+dpvthn                        k1=0.448
+ k2=0.048140709+dk2        lk2=-3.1115533e-010+dlk2  wk2=-3.7122147e-009
+ pk2=-9.1322366e-016       k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035
+ lkvth0we=-1.4299999e-010  wkvth0we=-1.2000011e-011  pkvth0we=1.5000009e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00048769918+dcitn   lcit=1.4475774e-010+dlcitn
+ wcit=8.8758178e-011       pcit=-1.0949483e-016+dpcitn
+ voff=-0.14850048+dvoffn   lvoff=-8.3937491e-009+dlvoffn
+ wvoff=-1.0682653e-009     pvoff=1.6194193e-015+dpvoffn
+ nfactor=1.305933          lnfactor=-1.6038562e-007  wnfactor=-7.3413756e-008
+ pnfactor=4.6006229e-014   eta0=0.0092251498+deta0n  leta0=1.3110407e-007+dleta0n
+ weta0=4.7248216e-008      peta0=-2.7511725e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.020914402+du0n       lu0=5.0764788e-009+dlu0n  wu0=3.0151699e-009
+ pu0=-1.0586033e-015+dpu0n ua=-4.7450936e-010        lua=1.8421903e-017
+ wua=6.3743975e-018        pua=-6.1719657e-023       ub=3.3755544e-019
+ lub=7.394269e-025         wub=2.2747064e-025        pub=-6.2706491e-032
+ uc=4.6796853e-011         luc=7.9323958e-017        wuc=1.8651644e-017
+ puc=-2.3803623e-023       vsat=77860.433+dvsatn     lvsat=-0.00081878711+dlvsatn
+ wvsat=-0.0035518874       pvsat=2.4125667e-009+dpvsatn
+ a0=-0.10275458+da0n       la0=4.6730518e-007+dla0n  wa0=2.9650415e-007
+ pa0=-1.4364985e-013+dpa0n ags=0.3065495             lags=4.8480478e-007
+ wags=1.0570427e-007       pags=-7.7370976e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.044479894         lketa=-1.8697001e-008     wketa=-6.9594572e-009
+ pketa=6.0268161e-015      dwg=0                     dwb=0
+ pclm=0.4744185+dpclmn     lpclm=2.1458817e-007+dlpclmn
+ wpclm=3.7800547e-008      ppclm=-4.28318e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0015597345+dpdiblc2n
+ lpdiblc2=-2.5589493e-010+dlpdiblc2n                 wpdiblc2=5.1804148e-011
+ ppdiblc2=1.462308e-016+dppdiblc2n                   pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.2930198            lkt1=-7.9050298e-009
+ wkt1=1.118395e-009        pkt1=2.599352e-015        kt1l=0
+ kt2=-0.053236802          lkt2=2.1924705e-009       wkt2=1.3056516e-009
+ pkt2=-5.3137195e-016      ute=-1.3891561            lute=1.4508792e-007
+ wute=6.0707017e-008       pute=-5.4287351e-014      ua1=3.2104053e-009
+ lua1=1.3757427e-016       wua1=7.2653302e-017       pua1=-1.9943698e-022
+ ub1=-4.1547516e-018       lub1=2.9650447e-025       wub1=-7.1031093e-026
+ pub1=1.6079175e-031       uc1=-4.151591e-011        luc1=4.6792241e-017
+ wuc1=-1.519636e-018       puc1=1.8490137e-024       prt=0
+ at=139748.8               lat=-0.046532186          wat=-0.0076660769
+ pat=3.5631809e-009        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     16: type=n 
+ lmin=1.8e-07              lmax=5e-007-(dxln+dlmisn) wmin=2.2e-07
+ wmax=5.3e-007-(dxwn+dwmisn)                         version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxn+toxmisn)
+ toxm=(toxn+toxmisn)       dtox=5.958e-010           epsrox=3.9
+ wint=1.02e-008            lint=2.595e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln+dlmisn) xw=0+(dxwn+dwmisn)        dlc=2.595e-008+dlcn
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.48719013+(dvthn+vthmisn)
+ lvth0=-5.4580876e-009+dlvthn                        wvth0=-6.4052624e-009+dwvthn
+ pvth0=7.8603777e-016+dpvthn                         k1=0.448
+ k2=0.04626793+dk2         lk2=4.9994489e-010+dlk2   wk2=-5.7836793e-009
+ pk2=-1.6072338e-017       k3=-3.7                   k3b=1.2
+ w0=0                      dvt0=0.09708              dvt1=0.3053
+ dvt2=-0.6939              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.633                minv=-0.34
+ voffl=-1.22e-009          dvtp0=1.46e-006           dvtp1=0
+ lpe0=9.921e-009           lpeb=2.178e-008           web=0
+ wec=0                     scref=1e-006              kvth0we=0.0035
+ lkvth0we=-1.4299999e-010  wkvth0we=-1.1999981e-011  pkvth0we=1.4999996e-017
+ k2we=0.0038               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00082193549+dcitn   lcit=-1.2910146e-018+dlcitn
+ wcit=-1.6405833e-010      pcit=6.5790105e-025+dpcitn
+ voff=-0.17614288+dvoffn   lvoff=3.5781717e-009+dlvoffn
+ wvoff=5.3393099e-009      pvoff=-1.1557015e-015+dpvoffn
+ nfactor=0.85596405        lnfactor=3.4495917e-008   wnfactor=7.3400719e-008
+ pnfactor=-1.7579119e-014  eta0=0.39703025+deta0n    leta0=-3.685432e-008+dleta0n
+ weta0=-3.4783194e-008     peta0=8.0160785e-015+dpeta0n
+ etab=-0.24211447          letab=-2.8535023e-008     wetab=-3.3575266e-008
+ petab=1.4541448e-014      ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.033118824+du0n       lu0=-2.092564e-010+dlu0n  wu0=3.3875357e-010
+ pu0=1.0055256e-016+dpu0n  ua=-3.335318e-010         lua=-4.263548e-017
+ wua=-1.6371084e-016       pua=1.1944258e-023        ub=1.9040785e-018
+ lub=6.0965752e-026        wub=1.5521224e-025        pub=-3.1411375e-032
+ uc=2.2466359e-010         luc=2.2898732e-018        wuc=-3.1489728e-017
+ puc=-2.0873949e-024       vsat=81637.162+dvsatn     lvsat=-0.0024544887+dlvsatn
+ wvsat=0.00038051534       pvsat=7.0944303e-010+dpvsatn
+ a0=0.85142296+da0n        la0=5.4050885e-008+dla0n  wa0=-1.0264022e-008
+ pa0=-1.0788557e-014+dpa0n ags=1.7021554             lags=-1.1963214e-007
+ wags=-9.8720178e-008      pags=1.1165252e-014       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.10549168          lketa=7.727204e-009       wketa=9.6001598e-009
+ pketa=-1.1451541e-015     dwg=0                     dwb=0
+ pclm=0.93788546+dpclmn    lpclm=1.3860637e-008+dlpclmn
+ wpclm=-4.5470853e-008     ppclm=-6.7669565e-015+dppclmn
+ pdiblc1=0                 pdiblc2=0.00072159941+dpdiblc2n
+ lpdiblc2=1.0710136e-010+dlpdiblc2n                  wpdiblc2=5.520414e-010
+ ppdiblc2=-7.0421953e-017+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=6.8                   rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.30289261           lkt1=-3.6291127e-009
+ wkt1=6.9925656e-009       pkt1=5.5248661e-017       kt1l=0
+ kt2=-0.047021566          lkt2=-4.993484e-010       wkt2=-6.5649373e-010
+ pkt2=3.1843319e-016       ute=-0.98679314           lute=-2.9175468e-008
+ wute=-9.2123567e-008      pute=1.1903575e-014       ua1=3.8640851e-009
+ lua1=-1.4553444e-016      wua1=-4.5695119e-016      pua1=2.9934724e-023
+ ub1=-3.6926465e-018       lub1=9.636675e-026        wub1=2.8897772e-025
+ pub1=4.8719324e-033       uc1=5.5143893e-011        luc1=4.9288809e-018
+ wuc1=7.1784539e-019       puc1=8.7996049e-025       prt=0
+ at=34566.399              lat=-0.0009776859         wat=0.00090202574
+ pat=-1.476644e-010        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
     } 
ends nch_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.8V STD-VT PMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt pch_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 xw= + 0 
+ + dxwp ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf * dmcg + 
+ dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor + (nf 
+ + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 1) * 
+ (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos 
+ temp1=parp1 temp2=parp2 fac1=0.754208 * temp1 * sigma + 0.656636 * temp2 * sigma 
+ fac2=0.754208 * temp1 * sigma - 0.656636 * temp2 * sigma lef=l * factor - 1.5e-08 
+ wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) vthmisp=0.00315499 
+ * geo_fac * fac1 * mismatchflag dlmisp=0.00204053 * geo_fac * lef * fac2 * mismatchflag 
+ dwmisp= - 0.00204053 * geo_fac * wef * fac2 * mismatchflag toxmisp=0.00204053 
+ * geo_fac * toxp * fac2 * mismatchflag 
pch_mac ( n1 n2 n3 n4 ) pch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model pch bsim4  { 
     1: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2e-05                wmin=1.003e-005-(dxwp+dwmisp)
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxp+toxmisp)
+ toxm=(toxp+toxmisp)       dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.459+(dvthp+vthmisp)
+ k1=0.493                  k2=0.04632+dk2p           k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055034962     lkvth0we=0                wkvth0we=0
+ pkvth0we=0                k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-1.6805e-013          voff=-0.12508+dvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.013907+du0p          ua=1.5887e-009
+ ub=1.478e-018             uc=1.058e-011             vsat=92640
+ a0=1.2107                 ags=0.456+dagsp           a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0334              dwg=0                     dwb=0
+ pclm=0.491                pdiblc1=0                 pdiblc2=0.000575
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.2635
+ kt1l=0                    kt2=-0.0372               ute=-1.121
+ ua1=2.729e-009            ub1=-5.53e-018            uc1=-9.549e-011
+ prt=0                     at=117200                 jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthp            wvth0=0+dwvthp
+ lk2=0+dlk2p               wk2=0+dwk2p               lcit=0+dlcitp
+ wcit=0+dwcitp             pcit=0+dpcitp             lvoff=0+dlvoffp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ lu0=0+dlu0p               wu0=0+dwu0p               lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           lpclm=0+dlpclmp
+ wpclm=0+dwpclmp           ppclm=0+dppclmp           lpdiblc2=0+dlpdiblc2p
+ wpdiblc2=0+dwpdiblc2p     ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     2: type=p 
+ lmin=1.2e-006-(dxlp+dlmisp)                         lmax=1e-005-(dxlp+dlmisp)
+ wmin=1.003e-005-(dxwp+dwmisp)                       wmax=90.003e-05
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.45586545+(dvthp+vthmisp)                    lvth0=-3.1088821e-008+dlvthp
+ k1=0.493                  k2=0.045966903+dk2p       lk2=3.5020605e-009+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098244     lkvth0we=6.2763377e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=3.2262844e-005
+ lcit=-3.1998676e-010+dlcitp                         voff=-0.12431637+dvoffp
+ lvoff=-7.5737257e-009+dlvoffp                       nfactor=0.95552932
+ lnfactor=4.4106556e-007+dlnfactorp                  eta0=0.189
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013958713+du0p
+ lu0=-5.1289624e-010+dlu0p ua=1.5084622e-009         lua=7.9580829e-016
+ ub=1.6295319e-018         lub=-1.502912e-024        uc=1.3911489e-011
+ luc=-3.3042111e-017       vsat=91133.079            lvsat=0.014945822+dlvsatp
+ a0=1.2697291              la0=-5.8545782e-007       ags=0.48090104+dagsp
+ lags=-2.4697151e-007      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.0334
+ dwg=0                     dwb=0                     pclm=0.48975228
+ lpclm=1.2375039e-008+dlpclmp                        pdiblc1=0
+ pdiblc2=0.00037857935     lpdiblc2=1.9481236e-009+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.26332212
+ lkt1=-1.7642622e-009      kt1l=0                    kt2=-0.037606589
+ lkt2=4.0325994e-009       ute=-1.131673             lute=1.0585573e-007
+ ua1=2.6610234e-009        lua1=6.7420021e-016       ub1=-5.4265739e-018
+ lub1=-1.0257925e-024      uc1=-8.6086357e-011       luc1=-9.3266463e-017
+ prt=0                     at=109220.69              lat=0.079139763
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  wvth0=0+dwvthp
+ wk2=0+dwk2p               wcit=0+dwcitp             pcit=0+dpcitp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           wu0=0+dwu0p
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           wpclm=0+dwpclmp
+ ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p     ppdiblc2=0+dppdiblc2p
+ leta0=0+dleta0p           weta0=0+dweta0p           peta0=0+dpeta0p
+ fnoimod=1                 noia=noiap                noib=noibp
+ noic=noicp                em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     3: type=p 
+ lmin=5e-007-(dxlp+dlmisp) lmax=1.2e-006-(dxlp+dlmisp)
+ wmin=1.003e-005-(dxwp+dwmisp)                       wmax=90.003e-05
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.48365805+(dvthp+vthmisp)                    lvth0=-1.3357381e-011+dlvthp
+ k1=0.493                  k2=0.047992177+dk2p       lk2=1.2375613e-009+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098242     lkvth0we=6.2763261e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00064690501
+ lcit=4.394044e-010+dlcitp voff=-0.13413033+dvoffp   lvoff=3.3994535e-009+dlvoffp
+ nfactor=1.55906           lnfactor=-2.3375417e-007+dlnfactorp
+ eta0=0.189                etab=-0.0159              ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.012394969+du0p       lu0=1.2355577e-009+dlu0p  ua=2.4998028e-009
+ lua=-3.126295e-016        ub=-1.1381951e-018        lub=1.591739e-024
+ uc=-1.0779365e-010        luc=1.0303884e-016        vsat=90863.315
+ lvsat=0.01524745+dlvsatp  a0=0.40572253             la0=3.8060521e-007
+ ags=-0.10427601+dagsp     lags=4.0732665e-007       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0099231593        lketa=-2.6249925e-008     dwg=0
+ dwb=0                     pclm=0.50668563           lpclm=-6.5584741e-009+dlpclmp
+ pdiblc1=0                 pdiblc2=0.0018138207      lpdiblc2=3.4335148e-010+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.2742181
+ lkt1=1.0418757e-008       kt1l=0                    kt2=-0.032088594
+ lkt2=-2.137181e-009       ute=-1.0607134            lute=2.6514388e-008
+ ua1=3.3518052e-009        lua1=-9.817675e-017       ub1=-6.908462e-018
+ lub1=6.3113625e-025       uc1=-2.7074477e-010       luc1=1.132038e-016
+ prt=0                     at=240591.56              lat=-0.067748636
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  wvth0=0+dwvthp
+ wk2=0+dwk2p               wcit=0+dwcitp             pcit=0+dpcitp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           wu0=0+dwu0p
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           wpclm=0+dwpclmp
+ ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p     ppdiblc2=0+dppdiblc2p
+ leta0=0+dleta0p           weta0=0+dweta0p           peta0=0+dpeta0p
+ fnoimod=1                 noia=noiap                noib=noibp
+ noic=noicp                em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     4: type=p 
+ lmin=1.8e-07              lmax=5e-007-(dxlp+dlmisp) wmin=1.003e-005-(dxwp+dwmisp)
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxp+toxmisp)
+ toxm=(toxp+toxmisp)       dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48927671+(dvthp+vthmisp)
+ lvth0=2.3359141e-009+dlvthp                         k1=0.493
+ k2=0.052087126+dk2p       lk2=-4.7461878e-010+dlk2p k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055098244     lkvth0we=6.2763333e-011   wkvth0we=0
+ pkvth0we=0                k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0002212515          lcit=7.6410803e-011+dlcitp
+ voff=-0.12935141+dvoffp   lvoff=1.4012921e-009+dlvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.014616246+du0p       lu0=3.0679707e-010+dlu0p
+ ua=1.8886708e-009         lua=-5.7102972e-017       ub=2.4383326e-018
+ lub=9.6321202e-026        uc=1.980118e-010          luc=-2.4824536e-017
+ vsat=142095.83            lvsat=-0.0061738903+dlvsatp
+ a0=1.316                  ags=0.99093795+dagsp      lags=-5.0604208e-008
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.084755589         lketa=5.0390104e-009
+ dwg=0                     dwb=0                     pclm=0.50605529
+ lpclm=-6.2949168e-009+dlpclmp                       pdiblc1=0
+ pdiblc2=0.0028326811      lpdiblc2=-8.2654437e-011+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.24396472
+ lkt1=-2.2307852e-009      kt1l=0                    kt2=-0.0411248
+ lkt2=1.6410374e-009       ute=-0.94066639           lute=-2.3679654e-008
+ ua1=3.5769375e-009        lua1=-1.9230907e-016      ub1=-5.9135167e-018
+ lub1=2.1512974e-025       uc1=2.3119515e-011        luc1=-9.6667348e-018
+ prt=0                     at=98883.105              lat=-0.0084974967
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  wvth0=0+dwvthp
+ wk2=0+dwk2p               wcit=0+dwcitp             pcit=0+dpcitp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ wu0=0+dwu0p               wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ wpclm=0+dwpclmp           ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p
+ ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     5: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2e-05                wmin=1.23e-006-(dxwp+dwmisp)
+ wmax=1.003e-005-(dxwp+dwmisp)                       version=4.5
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)       dtox=6.556e-010
+ epsrox=3.9                wint=-2.35e-008           lint=3.344e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)
+ dlc=3.344e-008+dlcp       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.45773606+(dvthp+vthmisp)
+ wvth0=-1.2736721e-008+dwvthp                        k1=0.493
+ k2=0.045916729+dk2p       wk2=4.0637598e-009+dwk2p  k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054941521     lkvth0we=0                wkvth0we=-9.4160342e-011
+ pkvth0we=0                k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-1.4511364e-005       wcit=1.4623101e-010+dwcitp
+ voff=-0.12477236+dvoffp   wvoff=-3.1000974e-009+dwvoffp
+ nfactor=1                 eta0=0.189                etab=-0.01703058
+ wetab=1.1392858e-008      ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013868835+du0p
+ wu0=3.8458756e-010+dwu0p  ua=1.5206127e-009         wua=6.8611591e-016
+ ub=1.5710004e-018         wub=-9.3716531e-025       uc=2.2020759e-011
+ wuc=-1.1528853e-016       vsat=92640                a0=1.2385473
+ wa0=-2.8061731e-007       ags=0.47029369+dagsp      wags=-1.4403755e-007
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.0334              dwg=0
+ dwb=0                     pclm=0.491                pdiblc1=0
+ pdiblc2=0.00062941761     wpdiblc2=-5.4836629e-010+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.26415301
+ wkt1=6.5803955e-009       kt1l=0                    kt2=-0.036925735
+ wkt2=-2.7637661e-009      ute=-1.1214353            wute=4.3869303e-009
+ ua1=2.7493159e-009        wua1=-2.0472342e-016      ub1=-5.5369655e-018
+ wub1=7.0190885e-026       uc1=-9.6938234e-011       wuc1=1.4593852e-017
+ prt=0                     at=118114.22              wat=-0.0092125537
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lvth0=0+dlvthp
+ lk2=0+dlk2p               lcit=0+dlcitp             pcit=0+dpcitp
+ lvoff=0+dlvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ lu0=0+dlu0p               lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           lpclm=0+dlpclmp           wpclm=0+dwpclmp
+ ppclm=0+dppclmp           lpdiblc2=0+dlpdiblc2p     ppdiblc2=0+dppdiblc2p
+ leta0=0+dleta0p           weta0=0+dweta0p           peta0=0+dpeta0p
+ fnoimod=1                 noia=noiap                noib=noibp
+ noic=noicp                em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     6: type=p 
+ lmin=1.2e-006-(dxlp+dlmisp)                         lmax=1e-005-(dxlp+dlmisp)
+ wmin=1.23e-006-(dxwp+dwmisp)                        wmax=1.003e-005-(dxwp+dwmisp)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.45427553+(dvthp+vthmisp)                    lvth0=-3.4321969e-008+dlvthp
+ wvth0=-1.6021661e-008+dwvthp                        pvth0=3.2580433e-014
+ k1=0.493                  k2=0.045549508+dk2p       lk2=3.6421392e-009+dlk2p
+ wk2=4.2060824e-009+dwk2p  pk2=-1.411573e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055           lkvth0we=5.8000061e-011   wkvth0we=-9.8999962e-011
+ pkvth0we=4.7999933e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=2.0589458e-005        lcit=-3.4813417e-010+dlcitp
+ wcit=1.1763271e-010+dwcitp                          pcit=2.8364141e-016+dpcitp
+ voff=-0.12396872+dvoffp   lvoff=-7.9705544e-009+dlvoffp
+ wvoff=-3.503283e-009+dwvoffp                        pvoff=3.9988427e-015+dpvoffp
+ nfactor=0.94907602        lnfactor=5.0507019e-007+dlnfactorp
+ wnfactor=6.5029928e-008   pnfactor=-6.4497463e-013  eta0=0.189
+ etab=-0.017174231         letab=1.424743e-009       wetab=1.2840424e-008
+ petab=-1.4357135e-014     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013937714+du0p
+ lu0=-6.8314854e-010+dlu0p wu0=2.1160795e-010+dwu0p  pu0=1.7156325e-015
+ ua=1.4324742e-009         lua=8.7416824e-016        wua=7.6573112e-016
+ pua=-7.8963322e-022       ub=1.7521381e-018         lub=-1.7965451e-024
+ wub=-1.2355022e-024       pub=2.9589409e-030        uc=2.621865e-011
+ luc=-4.163519e-017        wuc=-1.2401926e-016       puc=8.6592451e-023
+ vsat=91013.97             lvsat=0.016127164+dlvsatp wvsat=0.0012002667+dwvsatp
+ pvsat=-1.1904389e-008+dpvsatp                       a0=1.3116221
+ la0=-7.2476481e-007       wa0=-4.2215588e-007       pa0=1.4037965e-012
+ ags=0.50246724+dagsp      lags=-3.1910107e-007      wags=-2.1732256e-007
+ pags=7.2684955e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.033780265
+ lketa=3.7715184e-009      wketa=3.8319349e-009      pketa=-3.8005591e-014
+ dwg=0                     dwb=0                     pclm=0.48957122
+ lpclm=1.4170826e-008+dlpclmp                        wpclm=1.824554e-009+dwpclmp
+ ppclm=-1.8096145e-014+dppclmp                       pdiblc1=0
+ pdiblc2=0.00044934226     lpdiblc2=1.786009e-009+dlpdiblc2p
+ wpdiblc2=-7.1307781e-010+dwpdiblc2p                 ppdiblc2=1.6336286e-015+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.26387372
+ lkt1=-2.7700492e-009      wkt1=5.5584966e-009       pkt1=1.0135316e-014
+ kt1l=0                    kt2=-0.037379341          lkt2=4.4989188e-009
+ wkt2=-2.2899766e-009      pkt2=-4.6991009e-015      ute=-1.1309596
+ lute=9.4462912e-008       wute=-7.1883949e-009      pute=1.1480547e-013
+ ua1=2.6910192e-009        lua1=5.7819327e-016       wua1=-3.0226831e-016
+ pua1=9.6746194e-022       ub1=-5.4458191e-018       lub1=-9.0400081e-025
+ wub1=1.9393355e-025       pub1=-1.2272946e-030      uc1=-8.7508409e-011
+ luc1=-9.3526137e-017      wuc1=1.4330018e-017       puc1=2.6167395e-024
+ prt=0                     at=110619.82              lat=0.074330274
+ wat=-0.014099086          pat=4.8465218e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ saref=1.00e-05            sbref=1.00e-05            rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     7: type=p 
+ lmin=5e-007-(dxlp+dlmisp) lmax=1.2e-006-(dxlp+dlmisp)
+ wmin=1.23e-006-(dxwp+dwmisp)                        wmax=1.003e-005-(dxwp+dwmisp)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.48524403+(dvthp+vthmisp)                    lvth0=3.0453007e-010+dlvthp
+ wvth0=1.5981866e-008+dwvthp                         pvth0=-3.2033519e-015
+ k1=0.493                  k2=0.047324832+dk2p       lk2=1.6571146e-009+dlk2p
+ wk2=6.7248331e-009+dwk2p  pk2=-4.2278385e-015       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999931e-011   wkvth0we=-9.9000092e-011
+ pkvth0we=4.8000079e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00076158258        lcit=5.2642803e-010+dlcitp
+ wcit=1.1556058e-009+dwcitp                          pcit=-8.769371e-016+dpcitp
+ voff=-0.13429534+dvoffp   lvoff=3.5758422e-009+dlvoffp
+ wvoff=1.6628104e-009+dwvoffp                        pvoff=-1.7774696e-015+dpvoffp
+ nfactor=1.6401872         lnfactor=-2.6767508e-007+dlnfactorp
+ wnfactor=-8.1751909e-007  pnfactor=3.4182108e-013   eta0=0.18719796
+ leta0=2.0149025e-009+dleta0p                        weta0=1.8159207e-008+dweta0p
+ peta0=-2.0304172e-014+dpeta0p                       etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.012118209+du0p       lu0=1.3512765e-009+dlu0p
+ wu0=2.788908e-009+dwu0p   pu0=-1.1660982e-015       ua=2.6075928e-009
+ lua=-4.3975541e-016       wua=-1.0861998e-015       pua=1.2810478e-021
+ ub=-1.5190313e-018        lub=1.8610149e-024        wub=3.8376866e-024
+ pub=-2.713493e-030        uc=-1.2195413e-010        luc=1.2403976e-016
+ wuc=1.4269519e-016        puc=-2.1162632e-022       vsat=88037.344
+ lvsat=0.019455389+dlvsatp wvsat=0.028477307+dwvsatp pvsat=-4.2403394e-008+dpvsatp
+ a0=0.25681324             la0=4.546381e-007         wa0=1.5005589e-006
+ pa0=-7.460294e-013        ags=-0.1823676+dagsp      lags=4.4662646e-007
+ wags=7.8692894e-007       pags=-3.9602414e-013      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0054443204        lketa=-2.7911469e-008     wketa=-4.513326e-008
+ pketa=1.6743373e-014      dwg=0                     dwb=0
+ pclm=0.52300633           lpclm=-2.3213644e-008+dlpclmp
+ wpclm=-1.6446377e-007+dwpclmp                       ppclm=1.6783415e-013+dppclmp
+ pdiblc1=0                 pdiblc2=0.0017101591      lpdiblc2=3.7626446e-010+dlpdiblc2p
+ wpdiblc2=1.0445982e-009+dwpdiblc2p                  ppdiblc2=-3.3166411e-016+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27670071
+ lkt1=1.1572068e-008       wkt1=2.501726e-008        pkt1=-1.1621917e-014
+ kt1l=0                    kt2=-0.030643381          lkt2=-3.0326932e-009
+ wkt2=-1.4563415e-008      pkt2=9.0240766e-015       ute=-1.0722609
+ lute=2.88307e-008         wute=1.1636448e-007       pute=-2.3341477e-014
+ ua1=3.2818079e-009        lua1=-8.2379294e-017      wua1=7.0536317e-016
+ pua1=-1.5919096e-022      ub1=-6.8509395e-018       lub1=6.670924e-025
+ wub1=-5.7965464e-025      pub1=-3.6233015e-031      uc1=-2.7980053e-010
+ luc1=1.2147953e-016       wuc1=9.1254954e-017       puc1=-8.339457e-023
+ prt=0                     at=239036.27              lat=-0.069254726
+ wat=0.01567263            pat=1.5176866e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     8: type=p 
+ lmin=1.8e-07              lmax=5e-007-(dxlp+dlmisp) wmin=1.23e-006-(dxwp+dwmisp)
+ wmax=1.003e-005-(dxwp+dwmisp)                       version=4.5
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)       dtox=6.556e-010
+ epsrox=3.9                wint=-2.35e-008           lint=3.344e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)
+ dlc=3.344e-008+dlcp       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.48984522+(dvthp+vthmisp)
+ lvth0=2.2283804e-009+dlvthp                         wvth0=5.7289033e-009+dwvthp
+ pvth0=1.083617e-015       k1=0.493                  k2=0.052782109+dk2p
+ lk2=-6.2468224e-010+dlk2p wk2=-7.0033501e-009+dwk2p pk2=1.5121895e-015
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055000001     lkvth0we=5.8000013e-011
+ wkvth0we=-9.8999853e-011  pkvth0we=4.7999979e-017   k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00033001112
+ lcit=7.0010874e-011+dlcitp                          wcit=-1.0959707e-009+dwcitp
+ pcit=6.4492087e-017+dpcitp                          voff=-0.12851612+dvoffp
+ lvoff=1.1594343e-009+dlvoffp                        wvoff=-8.4172398e-009+dwvoffp
+ pvoff=2.437201e-015+dpvoffp                         nfactor=1.0075642
+ lnfactor=-3.1627557e-009+dlnfactorp                 wnfactor=-7.6224743e-008
+ pnfactor=3.1871089e-014   eta0=0.19294197           leta0=-3.8678642e-010+dleta0p
+ weta0=-3.9723265e-008+dweta0p                       peta0=3.8976468e-015+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.014489167+du0p
+ lu0=3.5993136e-010+dlu0p  wu0=1.2805757e-009+dwu0p  pu0=-5.354343e-016
+ ua=1.6733617e-009         lua=-4.9134688e-017       wua=2.1696697e-015
+ pua=-8.0296397e-023       ub=2.7179937e-018         lub=8.9429929e-026
+ wub=-2.818145e-024        pub=6.9443354e-032        uc=2.4549014e-010
+ luc=-2.9596037e-017       wuc=-4.7843924e-016       puc=4.8082413e-023
+ vsat=151703.6             lvsat=-0.0071647445+dlvsatp
+ wvsat=-0.096817419+dwvsatp                          pvsat=9.9848373e-009+dpvsatp
+ a0=1.3527842              la0=-3.6092624e-009       wa0=-3.7067404e-007
+ pa0=3.6370537e-014        ags=1.011927+dagsp        lags=-5.2731998e-008
+ wags=-2.1150664e-007      pags=2.1441744e-014       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.084095749         lketa=4.9742669e-009      wketa=-6.6492045e-009
+ pketa=6.5241995e-016      dwg=0                     dwb=0
+ pclm=0.47402209           lpclm=-2.7323516e-009+dlpclmp
+ wpclm=3.2279855e-007+dwpclmp                        ppclm=-3.589997e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.002799807       lpdiblc2=-7.9339125e-011+dlpdiblc2p
+ wpdiblc2=3.3127257e-010+dwpdiblc2p                  ppdiblc2=-3.3408401e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.24300823
+ lkt1=-2.5154332e-009      wkt1=-9.638616e-009       pkt1=2.868398e-015
+ kt1l=0                    kt2=-0.04246208           lkt2=1.9089414e-009
+ wkt2=1.3475773e-008       pkt2=-2.6996687e-015      ute=-0.93501183
+ lute=-2.8555879e-008      wute=-5.6980956e-008      pute=4.9137717e-014
+ ua1=3.63091e-009          lua1=-2.2834588e-016      wua1=-5.4388079e-016
+ pua1=3.6314292e-022       ub1=-5.8435059e-018       lub1=2.4586429e-025
+ wub1=-7.0549913e-025      pub1=-3.0971205e-031      uc1=3.9003709e-011
+ luc1=-1.1818897e-017      wuc1=-1.6006502e-016      puc1=2.1687339e-023
+ prt=0                     at=92130.159              lat=-0.0078303414
+ wat=0.068049435           pat=-6.7229236e-009       jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     9: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2e-05                wmin=5.3e-007-(dxwp+dwmisp)
+ wmax=1.23e-006-(dxwp+dwmisp)                        version=4.5
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)       dtox=6.556e-010
+ epsrox=3.9                wint=-2.35e-008           lint=3.344e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)
+ dlc=3.344e-008+dlcp       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.46311873+(dvthp+vthmisp)
+ wvth0=-5.8630536e-009+dwvthp                        k1=0.493
+ k2=0.046955033+dk2p       wk2=2.737846e-009+dwk2p   k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.005494152      lkvth0we=0                wkvth0we=-9.4160431e-011
+ pkvth0we=0                k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00018242858         wcit=-1.0526129e-010+dwcitp
+ voff=-0.11884174+dvoffp   wvoff=-1.0673494e-008+dwvoffp
+ nfactor=1                 eta0=0.189                etab=-0.00168699
+ wetab=-8.2009068e-009     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.014927519+du0p
+ wu0=-9.6735122e-010+dwu0p ua=2.1980286e-009         wua=-1.7894419e-016
+ ub=1.2778079e-018         wub=-5.6275841e-025       uc=-3.7398743e-011
+ wuc=-3.9409825e-017       vsat=92640                a0=0.86597743
+ wa0=1.9515442e-007        ags=0.38476737+dagsp      wags=-3.4820433e-008
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.038840286         wketa=6.9472449e-009
+ dwg=0                     dwb=0                     pclm=0.55980313
+ wpclm=-8.7861595e-008+dwpclmp                       pdiblc1=0
+ pdiblc2=0.00012993571     wpdiblc2=8.9472093e-011+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27152914
+ wkt1=1.5999715e-008       kt1l=0                    kt2=-0.043285614
+ wkt2=5.3577994e-009       ute=-1.0998657            wute=-2.3157483e-008
+ ua1=2.9459157e-009        wua1=-4.5578137e-016      ub1=-6.2255057e-018
+ wub1=9.494568e-025        uc1=-1.3602223e-010       wuc1=6.4504116e-017
+ prt=0                     at=129248.6               wat=-0.023431166
+ jss=1.76e-07              jsd=1.76e-07              jsws=2.71e-13
+ jswd=2.71e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10.2                  bvd=10.2                  xjbvs=1
+ xjbvd=1                   pbs=0.86                  pbd=0.86
+ cjs=cjp                   cjd=cjp                   mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.45765
+ mjswgd=0.45765            tpb=0.00161               tcj=0.000918
+ tpbsw=0.00125             tcjsw=0.000886            tpbswg=0.00115
+ tcjswg=0.000723           xtis=3                    xtid=3
+ jtsswgs=6.5702e-011       jtsswgd=6.5702e-011       njtsswg=7.1
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=0
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=0
+ rshg=1                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=1e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=5.54e-008
+ lku0=5e-008               wku0=1e-008               pku0=1e-014
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lvth0=0+dlvthp
+ lk2=0+dlk2p               lcit=0+dlcitp             pcit=0+dpcitp
+ lvoff=0+dlvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ lu0=0+dlu0p               lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           lpclm=0+dlpclmp           ppclm=0+dppclmp
+ lpdiblc2=0+dlpdiblc2p     ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     10: type=p 
+ lmin=1.2e-006-(dxlp+dlmisp)                         lmax=1e-005-(dxlp+dlmisp)
+ wmin=5.3e-007-(dxwp+dwmisp)                         wmax=1.23e-006-(dxwp+dwmisp)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.46278043+(dvthp+vthmisp)                    lvth0=-3.3552487e-009+dlvthp
+ wvth0=-5.1608974e-009+dwvthp                        pvth0=-6.9640692e-015
+ k1=0.493                  k2=0.046549495+dk2p       lk2=4.0221758e-009+dlk2p
+ wk2=2.9291e-009+dwk2p     pk2=-1.8968798e-015       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999947e-011   wkvth0we=-9.9000065e-011
+ pkvth0we=4.8000079e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00022655438         lcit=-4.3764506e-010+dlcitp
+ wcit=-1.453845e-010+dwcitp                          pcit=3.9794682e-016+dpcitp
+ voff=-0.11772334+dvoffp   lvoff=-1.1092421e-008+dlvoffp
+ wvoff=-1.1478633e-008+dwvoffp                       pvoff=7.985466e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=0.00011890213
+ letab=-1.7911055e-008     wetab=-9.2429065e-009     petab=1.0334679e-014
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.015067159+du0p       lu0=-1.3849693e-009+dlu0p
+ wu0=-1.2306932e-009+dwu0p pu0=2.6118576e-015        ua=2.2366778e-009
+ lua=-3.8332756e-016       wua=-2.6123689e-016       pua=8.1618891e-022
+ ub=1.2299065e-018         lub=4.7509189e-025        wub=-5.6861239e-025
+ pub=5.806044e-032         uc=-4.7868646e-011        luc=1.0384176e-016
+ wuc=-2.9409784e-017       puc=-9.918161e-023        vsat=91765.362
+ lvsat=0.0086747694+dlvsatp                          wvsat=0.00024073926+dwvsatp
+ pvsat=-2.3876809e-009+dpvsatp                       a0=0.81293492
+ la0=5.2608194e-007        wa0=2.1466768e-007        pa0=-1.935348e-013
+ ags=0.36180321+dagsp      lags=2.2776134e-007       wags=-3.7694593e-008
+ pags=2.8506256e-014       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.036820149
+ lketa=-2.0035963e-008     wketa=7.7138657e-009      pketa=-7.603437e-015
+ dwg=0                     dwb=0                     pclm=0.5726591
+ lpclm=-1.275071e-007+dlpclmp                        wpclm=-1.0427868e-007+dwpclmp
+ ppclm=1.6282657e-013+dppclmp                        pdiblc1=0
+ pdiblc2=-0.00019470709    lpdiblc2=3.2198463e-009+dlpdiblc2p
+ wpdiblc2=1.093732e-010+dwpdiblc2p                   ppdiblc2=-1.9738162e-016+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27417616
+ lkt1=2.6253482e-008       wkt1=1.8714719e-008       pkt1=-2.6927734e-014
+ kt1l=0                    kt2=-0.04427938           lkt2=9.856285e-009
+ wkt2=6.5213725e-009       pkt2=-1.1540457e-014      ute=-1.1461354
+ lute=4.5890817e-007       wute=1.2191064e-008       pute=-3.5059113e-013
+ ua1=2.6829352e-009        lua1=2.6082727e-015       wua1=-2.9194493e-016
+ pua1=-1.6249495e-021      ub1=-5.9918994e-018       lub1=-2.3169354e-024
+ wub1=8.9127814e-025       pub1=5.7702287e-031       uc1=-1.2181791e-010
+ luc1=-1.4088017e-016      wuc1=5.8143249e-017       puc1=6.3087841e-023
+ prt=0                     at=112582.07              lat=0.1653007
+ wat=-0.016604872          pat=-6.7704012e-008       jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     11: type=p 
+ lmin=5e-007-(dxlp+dlmisp) lmax=1.2e-006-(dxlp+dlmisp)
+ wmin=5.3e-007-(dxwp+dwmisp)                         wmax=1.23e-006-(dxwp+dwmisp)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.46431722+(dvthp+vthmisp)                    lvth0=-1.6369375e-009+dlvthp
+ wvth0=-1.0741668e-008+dwvthp                        pvth0=-7.2409777e-016
+ k1=0.493                  k2=0.052094928+dk2p       lk2=-2.1782845e-009+dlk2p
+ wk2=6.3341977e-010+dwk2p  pk2=6.6996619e-016        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055           lkvth0we=5.8000032e-011   wkvth0we=-9.8999949e-011
+ pkvth0we=4.7999949e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00026308099         lcit=-4.7848619e-010+dlcitp
+ wcit=-1.5288955e-010+dwcitp                         pcit=4.0633836e-016+dpcitp
+ voff=-0.13306828+dvoffp   lvoff=6.065062e-009+dlvoffp
+ wvoff=9.5856942e-011+dwvoffp                        pvoff=-4.9562032e-015+dpvoffp
+ nfactor=1                 eta0=0.21165428           leta0=-2.5330203e-008+dleta0p
+ weta0=-1.3071519e-008+dweta0p                       peta0=1.4615527e-014+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013242673+du0p
+ lu0=6.5502497e-010+dlu0p  wu0=1.3529673e-009+dwu0p  pu0=-2.7698497e-016
+ ua=1.1103413e-009         lua=8.7605175e-016        wua=8.2579035e-016
+ pua=-3.9923799e-022       ub=2.2473151e-018         lub=-6.6249308e-025
+ wub=-9.7193782e-025       pub=5.0902668e-031        uc=1.0291619e-010
+ luc=-6.4753787e-017       wuc=-1.4446421e-016       puc=2.9463046e-023
+ vsat=116536.53            lvsat=-0.019022369+dlvsatp
+ wvsat=-0.0079161528+dwvsatp                         pvsat=6.7327033e-009+dpvsatp
+ a0=1.4753889              la0=-2.1462115e-007       wa0=-5.556223e-008
+ pa0=1.0861467e-013        ags=0.41986894+dagsp      lags=1.6283688e-007
+ wags=1.7872885e-008       pags=-3.3624851e-014      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.042199189         lketa=-1.402155e-008      wketa=1.8027073e-009
+ pketa=-9.9405267e-016     dwg=0                     dwb=0
+ pclm=0.32811765           lpclm=1.4591959e-007+dlpclmp
+ wpclm=8.4409083e-008+dwpclmp                        ppclm=-4.8148987e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.0025703201      lpdiblc2=1.2821407e-010+dlpdiblc2p
+ wpdiblc2=-5.3827398e-011+dwpdiblc2p                 ppdiblc2=-1.490376e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.25078907
+ lkt1=1.0390134e-010       wkt1=-8.0719106e-009      pkt1=3.0229325e-015
+ kt1l=0                    kt2=-0.038082468          lkt2=2.9273941e-009
+ wkt2=-5.0637012e-009      pkt2=1.4130452e-015       ute=-0.36258271
+ lute=-4.1719775e-007      wute=-7.8989456e-007      pute=5.4623685e-013
+ ua1=8.1928905e-009        lua1=-3.5525186e-015      wua1=-5.5660894e-015
+ pua1=4.2721769e-021       ub1=-1.1065167e-017       lub1=3.3555871e-024
+ wub1=4.8019145e-024       pub1=-3.7955379e-030      uc1=-4.4391633e-010
+ luc1=2.1926452e-016       wuc1=3.0083083e-016       puc1=-2.08266e-022
+ prt=0                     at=343683.44              lat=-0.093098368
+ wat=-0.1179618            pat=4.5625197e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     12: type=p 
+ lmin=1.8e-07              lmax=5e-007-(dxlp+dlmisp) wmin=5.3e-007-(dxwp+dwmisp)
+ wmax=1.23e-006-(dxwp+dwmisp)                        version=4.5
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)       dtox=6.556e-010
+ epsrox=3.9                wint=-2.35e-008           lint=3.344e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)
+ dlc=3.344e-008+dlcp       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.47709758+(dvthp+vthmisp)
+ lvth0=3.7067884e-009+dlvthp                         wvth0=-1.0549828e-008+dwvthp
+ pvth0=-8.0430993e-016     k1=0.493                  k2=0.044959723+dk2p
+ lk2=8.0508781e-010+dlk2p  wk2=2.9858379e-009+dwk2p  pk2=-3.1362689e-016
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0054999999     lkvth0we=5.7999984e-011
+ wkvth0we=-9.9000108e-011  pkvth0we=4.8000016e-017   k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.001416708
+ lcit=2.2386717e-010+dlcitp                          wcit=1.1345896e-009+dwcitp
+ pcit=-1.319824e-016+dpcitp                          voff=-0.12335005+dvoffp-0.0037911991
+ lvoff=2.0016755e-009+dlvoffp+1.5851762e-09          wvoff=-1.5014308e-008+dwvoffp+4.8413613e-09
+ pvoff=1.3616589e-015+dpvoffp-2.02427e-15            nfactor=0.90490683
+ lnfactor=3.9760358e-008+dlnfactorp                  wnfactor=5.4868761e-008
+ pnfactor=-2.2941726e-014  eta0=0.13308213           leta0=7.5223835e-009+dleta0p
+ weta0=3.6717752e-008+dweta0p                        peta0=-6.2023632e-015+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.015670806+du0p
+ lu0=-3.6022584e-010+dlu0p wu0=-2.2837633e-010+dwu0p pu0=3.8420644e-016
+ ua=3.9336567e-009         lua=-3.0443287e-016       wua=-7.1672704e-016
+ pua=2.4571938e-022        ub=1.323592e-019          lub=2.2181229e-025
+ wub=4.8371032e-025        pub=-9.9608927e-032       uc=-1.158162e-010
+ luc=2.6702601e-017        wuc=-1.7051042e-017       puc=-2.3810948e-023
+ vsat=70977.126            lvsat=2.6928398e-005+dlvsatp
+ wvsat=0.0062702822+dwvsatp                          pvsat=8.010711e-010+dpvsatp
+ a0=0.92737249             la0=1.4515488e-008        wa0=1.7257667e-007
+ pa0=1.322523e-014         ags=0.84053845+dagsp      lags=-1.3053452e-008
+ wags=7.3565455e-009       pags=-2.9227759e-014      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.088714584         lketa=5.427467e-009       wketa=-7.5095217e-010
+ pketa=7.3683427e-017      dwg=0                     dwb=0
+ pclm=0.7535018            lpclm=-3.1942034e-008+dlpclmp
+ wpclm=-3.4097044e-008+dwpclmp                       ppclm=1.4007948e-015+dppclmp
+ pdiblc1=0                 pdiblc2=0.0032170396      lpdiblc2=-1.421923e-010+dlpdiblc2p
+ wpdiblc2=-2.0153347e-010+dwpdiblc2p                 ppdiblc2=4.6855102e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.24355272
+ lkt1=-2.9217608e-009      wkt1=-8.9433015e-009      pkt1=3.3872784e-015
+ kt1l=0                    kt2=-0.029377359          lkt2=-7.1238605e-010
+ wkt2=-3.2334162e-009      pkt2=6.4776639e-016       ute=-1.5461709
+ lute=7.7684143e-008       wute=7.2346917e-007       pute=-8.6530791e-014
+ ua1=-2.1574544e-009       lua1=7.7516763e-016       wua1=6.8478606e-015
+ pua1=-9.1834382e-022      ub1=-1.293409e-018        lub1=-7.3018056e-025
+ wub1=-6.5159729e-024      pub1=9.3669722e-031       uc1=1.7682462e-010
+ luc1=-4.027969e-017       wuc1=-3.3606233e-016      puc1=5.8031772e-023
+ prt=0                     at=153970.35              lat=-0.013775532
+ wat=-0.010920492          pat=8.6908522e-010        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     13: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2e-05                wmin=2.2e-07
+ wmax=5.3e-007-(dxwp+dwmisp)                         version=4.5
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)       dtox=6.556e-010
+ epsrox=3.9                wint=-2.35e-008           lint=3.344e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)
+ dlc=3.344e-008+dlcp       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.47328+(dvthp+vthmisp)
+ k1=0.493                  k2=0.061901123+dk2p       wk2=-5.8860477e-009+dwk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0054941522     lkvth0we=0
+ wkvth0we=-9.4160364e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-1.0651293e-011
+ wcit=2.5462971e-018+dwcitp                          voff=-0.13842523+dvoffp
+ wvoff=6.2617529e-010+dwvoffp                        nfactor=1
+ eta0=0.189                etab=-0.0159              ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.013251+du0p          ua=1.7655106e-009         wua=7.0618658e-017
+ ub=3.5625174e-019         wub=-3.1020525e-026       uc=-1.057e-010
+ vsat=92640                a0=1.1079077              wa0=5.5560633e-008
+ ags=0.21935981+dagsp      wags=6.0619732e-008       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.042649809         wketa=9.1453398e-009      dwg=0
+ dwb=0                     pclm=0.4667351            wpclm=-3.4161341e-008+dwpclmp
+ pdiblc1=0                 pdiblc2=0.00027208065     wpdiblc2=7.4544677e-012+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.2438
+ kt1l=0                    kt2=-0.034                ute=-1.14
+ ua1=2.156e-009            ub1=-4.58e-018            uc1=-2.4230005e-011
+ wuc1=1.4908935e-024       prt=0                     at=88639.993
+ wat=1.4908936e-009        jss=1.76e-07              jsd=1.76e-07
+ jsws=2.71e-13             jswd=2.71e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.2                  bvd=10.2
+ xjbvs=1                   xjbvd=1                   pbs=0.86
+ pbd=0.86                  cjs=cjp                   cjd=cjp
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswp               cjswd=cjswp
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.45765            mjswgd=0.45765            tpb=0.00161
+ tcj=0.000918              tpbsw=0.00125             tcjsw=0.000886
+ tpbswg=0.00115            tcjswg=0.000723           xtis=3
+ xtid=3                    jtsswgs=6.5702e-011       jtsswgd=6.5702e-011
+ njtsswg=7.1               xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=0                     rshg=1                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=1.00e-05            sbref=1.00e-05            wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=1e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=5.54e-008             lku0=5e-008               wku0=1e-008
+ pku0=1e-014               llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ lvth0=0+dlvthp            wvth0=0+dwvthp            lk2=0+dlk2p
+ lcit=0+dlcitp             pcit=0+dpcitp             lvoff=0+dlvoffp
+ pvoff=0+dpvoffp           lnfactor=0+dlnfactorp     lu0=0+dlu0p
+ wu0=0+dwu0p               lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           lpclm=0+dlpclmp           ppclm=0+dppclmp
+ lpdiblc2=0+dlpdiblc2p     ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     14: type=p 
+ lmin=1.2e-006-(dxlp+dlmisp)                         lmax=1e-005-(dxlp+dlmisp)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwp+dwmisp)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.47105506+(dvthp+vthmisp)                    lvth0=-2.2067262e-008+dlvthp
+ wvth0=-3.8644042e-010+dwvthp                        pvth0=3.8327625e-015
+ k1=0.493                  k2=0.062202518+dk2p       lk2=-2.9892741e-009+dlk2p
+ wk2=-6.1026943e-009+dwk2p pk2=2.1487268e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055000001     lkvth0we=5.8000146e-011   wkvth0we=-9.8999987e-011
+ pkvth0we=4.7999964e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-4.7298785e-005       lcit=4.6911492e-010+dlcitp
+ wcit=1.2628776e-011+dwcitp                          pcit=-1.2525369e-016+dpcitp
+ voff=-0.1381244+dvoffp    lvoff=-2.9836357e-009+dlvoffp
+ wvoff=2.9277571e-010+dwvoffp                        pvoff=3.306697e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.012761991+du0p       lu0=4.8500463e-009+dlu0p
+ wu0=9.9388435e-011+dwu0p  pu0=-9.8574643e-016       ua=1.7151175e-009
+ lua=4.9980573e-016        wua=3.9703424e-017        pua=3.06621e-022
+ ub=8.0525916e-020         lub=2.7346818e-024        wub=9.4580189e-026
+ pub=-1.245723e-030        uc=-1.1180683e-010        luc=6.0568261e-017
+ wuc=7.4825474e-018        puc=-7.4212803e-023       vsat=91788.622
+ lvsat=0.008444068+dlvsatp wvsat=0.00022731789+dwvsatp
+ pvsat=-2.2545662e-009+dpvsatp                       a0=1.0721262
+ la0=3.5488541e-007        wa0=6.5114299e-008        pa0=-9.4754405e-014
+ ags=0.16739788+dagsp      lags=5.1536466e-007       wags=7.4477283e-008
+ pags=-1.3744086e-013      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.037358179
+ lketa=-5.2483026e-008     wketa=8.024309e-009       pketa=1.1118518e-014
+ dwg=0                     dwb=0                     pclm=0.46510904
+ lpclm=1.6127471e-008+dlpclmp                        wpclm=-4.2222286e-008+dwpclmp
+ ppclm=7.9949421e-014+dppclmp                        pdiblc1=0
+ pdiblc2=-9.1744484e-006   lpdiblc2=2.7895218e-009+dlpdiblc2p
+ wpdiblc2=2.320872e-012+dwpdiblc2p                   ppdiblc2=5.0915619e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.23976087
+ lkt1=-4.0060542e-008      wkt1=-1.1429039e-009      pkt1=1.1335458e-014
+ kt1l=0                    kt2=-0.032096224          lkt2=-1.8881875e-008
+ wkt2=-5.0830813e-010      pkt2=5.0414611e-015       ute=-1.0845709
+ lute=-5.4975265e-007      wute=-2.3331656e-008      pute=2.3140617e-013
+ ua1=2.40634e-009          lua1=-2.4829023e-015      wua1=-1.3234953e-016
+ pua1=1.3126585e-021       ub1=-4.5776695e-018       lub1=-2.3114274e-026
+ wub1=7.5267481e-026       pub1=-7.4651191e-031      uc1=-2.9436795e-011
+ luc1=5.1641576e-017       wuc1=4.8393468e-018       puc1=-4.7997207e-023
+ prt=0                     at=75410.479              lat=0.13121191
+ wat=0.0048431353          pat=-4.8034783e-008       jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     15: type=p 
+ lmin=5e-007-(dxlp+dlmisp) lmax=1.2e-006-(dxlp+dlmisp)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwp+dwmisp)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)
+ dtox=6.556e-010           epsrox=3.9                wint=-2.35e-008
+ lint=3.344e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp)
+ xw=0+(dxwp+dwmisp)        dlc=3.344e-008+dlcp       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.49135323+(dvthp+vthmisp)                    lvth0=6.2852941e-010+dlvthp
+ wvth0=4.8581081e-009+dwvthp                         pvth0=-2.0312722e-015
+ k1=0.493                  k2=0.060186145+dk2p       lk2=-7.3472705e-010+dlk2p
+ wk2=-4.0352121e-009+dwk2p pk2=-1.6296644e-016       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999998     lkvth0we=5.7999904e-011   wkvth0we=-9.900004e-011
+ pkvth0we=4.8000024e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00014052712         lcit=2.5910302e-010+dlcitp
+ wcit=-8.2175962e-011+dwcitp                         pcit=-1.9250614e-017+dpcitp
+ voff=-0.14099926+dvoffp   lvoff=2.3080262e-010+dlvoffp
+ wvoff=4.6720307e-009+dwvoffp                        pvoff=-1.5898356e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.016605688+du0p       lu0=5.5233201e-010+dlu0p
+ wu0=-5.8749248e-010+dwu0p pu0=-2.1773114e-016       ua=2.072246e-009
+ lua=1.0049318e-016        wua=2.7077137e-016        pua=4.825931e-023
+ ub=1.6993676e-018         lub=9.2462252e-025        wub=-6.5577213e-025
+ pub=-4.0673902e-031       uc=-1.0676735e-010        luc=5.4933522e-017
+ wuc=-2.3476805e-017       puc=-3.9596531e-023       vsat=104264.2
+ lvsat=-0.0055051196+dlvsatp                         wvsat=-0.00083501563+dwvsatp
+ pvsat=-1.0667498e-009+dpvsatp                       a0=1.480818
+ la0=-1.0208098e-007       wa0=-5.8694769e-008       pa0=4.367899e-014
+ ags=0.38698297+dagsp      lags=2.6984217e-007       wags=3.6848087e-008
+ pags=-9.5366901e-014      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.06312954
+ lketa=-2.3667551e-008     wketa=1.387952e-008       pketa=4.57169e-015
+ dwg=0                     dwb=0                     pclm=0.50323683
+ lpclm=-2.6503974e-008+dlpclmp                       wpclm=-1.6634681e-008+dwpclmp
+ ppclm=5.1339409e-014+dppclmp                        pdiblc1=0
+ pdiblc2=0.0023486111      lpdiblc2=1.5323458e-010+dlpdiblc2p
+ wpdiblc2=7.4098693e-011+dwpdiblc2p                  ppdiblc2=-2.9340598e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.27321686
+ lkt1=-2.6527328e-009      wkt1=4.8689261e-009       pkt1=4.6135103e-015
+ kt1l=0                    kt2=-0.061431514          lkt2=1.3918499e-008
+ wkt2=8.4086983e-009       pkt2=-4.9288222e-015      ute=-2.5510369
+ lute=1.0899324e-006       wute=4.7284353e-007       pute=-3.2337723e-013
+ ua1=-7.2851481e-009       lua1=8.3533443e-015       wua1=3.3647389e-015
+ pua1=-2.597506e-021       ub1=1.8185611e-018        lub1=-7.1748676e-024
+ wub1=-2.6319968e-024      pub1=2.2805345e-030       uc1=3.6526313e-010
+ luc1=-3.896803e-016       wuc1=-1.6606572e-016      puc1=1.4309516e-022
+ prt=0                     at=244763.69              lat=-0.058145303
+ wat=-0.060885106          pat=2.5457278e-008        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     16: type=p 
+ lmin=1.8e-07              lmax=5e-007-(dxlp+dlmisp) wmin=2.2e-07
+ wmax=5.3e-007-(dxwp+dwmisp)                         version=4.5
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp+toxmisp)       toxm=(toxp+toxmisp)       dtox=6.556e-010
+ epsrox=3.9                wint=-2.35e-008           lint=3.344e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlp+dlmisp) xw=0+(dxwp+dwmisp)
+ dlc=3.344e-008+dlcp       dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.49241047+(dvthp+vthmisp)
+ lvth0=1.0705825e-009+dlvthp                         wvth0=-1.7142946e-009+dwvthp
+ pvth0=7.1678087e-016      k1=0.493                  k2=0.056440429+dk2p
+ lk2=8.314315e-010+dlk2p   wk2=-3.6385299e-009+dwk2p pk2=-3.2882721e-016
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055000001     lkvth0we=5.8000025e-011
+ wkvth0we=-9.8999965e-011  pkvth0we=4.7999992e-017   k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00081359137
+ lcit=-2.2318605e-011+dlcitp                         wcit=-1.5229316e-010+dwcitp
+ pcit=1.0066789e-017+dpcitp                          voff=-0.15167884+dvoffp+0.0085607722
+ lvoff=4.6961502e-009+dlvoffp-3.5794301e-09          wvoff=1.3314046e-009+dwvoffp-2.2857262e-09
+ pvoff=-1.9305298e-016+dpvoffp+9.5570783e-16         nfactor=1
+ eta0=0.19443335           leta0=-2.2717904e-009+dleta0p
+ weta0=1.3181021e-009+dweta0p                        peta0=-5.5112485e-016+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016704734+du0p
+ lu0=5.1091887e-010+dlu0p  wu0=-8.2495321e-010+dwu0p pu0=-1.1844406e-016
+ ua=1.8777014e-009         lua=1.8183616e-016        wua=4.6955918e-016
+ pua=-3.485785e-023        ub=3.5667728e-018         lub=1.4382307e-025
+ wub=-1.4979463e-024       pub=-5.4609145e-032       uc=6.1745049e-011
+ luc=-1.5524884e-017       wuc=-1.1950388e-016       puc=5.5431054e-025
+ vsat=84312.007            lvsat=0.0028372891+dlvsatp
+ wvsat=-0.0014239441+dwvsatp                         pvsat=-8.2050703e-010+dpvsatp
+ a0=1.2131375              la0=9.8415509e-009        wa0=7.6902339e-009
+ pa0=1.5922092e-014        ags=1.320679+dagsp        lags=-1.2055482e-007
+ wags=-2.6968456e-007      pags=3.280053e-014        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.14103023          lketa=8.9042862e-009      wketa=2.9435177e-008
+ pketa=-1.9324412e-015     dwg=0                     dwb=0
+ pclm=0.43394723           lpclm=2.4673915e-009+dlpclmp
+ wpclm=1.5028595e-007+dwpclmp                        ppclm=-1.8453444e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.0028285795      lpdiblc2=-4.7449802e-011+dlpdiblc2p
+ wpdiblc2=2.2608022e-011+dwpdiblc2p                  ppdiblc2=-7.8113186e-018+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=10.5                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.29620025
+ lkt1=6.9570804e-009       wkt1=2.1434322e-008       pkt1=-2.3128129e-015
+ kt1l=0                    kt2=-0.032837576          lkt2=1.9628015e-009
+ wkt2=-1.2368709e-009      pkt2=-8.958168e-016       ute=0.25467603
+ lute=-8.319233e-008       wute=-3.1561951e-007      pute=6.294934e-015
+ ua1=1.4789977e-008        lua1=-8.7670686e-016      wua1=-2.9308072e-015
+ pua1=3.4787759e-023       ub1=-1.7556488e-017       lub1=9.2622787e-025
+ wub1=2.8678236e-024       pub1=-1.9050443e-032      uc1=-8.0993047e-010
+ luc1=1.0169165e-016       wuc1=2.3329536e-016       puc1=-2.3885689e-023
+ prt=0                     at=140368.15              lat=-0.014495439
+ wat=-0.0030720205         pat=1.2844711e-009        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=0                     rshg=1
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
     } 
ends pch_mac
// 
 
